* NGSPICE file created from sm_cpu.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_1 abstract view
.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_2 abstract view
.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_4 abstract view
.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2oi_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_4 abstract view
.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_2 abstract view
.subckt sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_4 abstract view
.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_2 abstract view
.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_4 abstract view
.subckt sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_8 abstract view
.subckt sky130_fd_sc_hd__mux2_8 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_2 abstract view
.subckt sky130_fd_sc_hd__o311a_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_2 abstract view
.subckt sky130_fd_sc_hd__o2111a_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

.subckt sm_cpu clk imAddr[0] imAddr[10] imAddr[11] imAddr[12] imAddr[13] imAddr[14]
+ imAddr[15] imAddr[16] imAddr[17] imAddr[18] imAddr[19] imAddr[1] imAddr[20] imAddr[21]
+ imAddr[22] imAddr[23] imAddr[24] imAddr[25] imAddr[26] imAddr[27] imAddr[28] imAddr[29]
+ imAddr[2] imAddr[30] imAddr[31] imAddr[3] imAddr[4] imAddr[5] imAddr[6] imAddr[7]
+ imAddr[8] imAddr[9] imData[0] imData[10] imData[11] imData[12] imData[13] imData[14]
+ imData[15] imData[16] imData[17] imData[18] imData[19] imData[1] imData[20] imData[21]
+ imData[22] imData[23] imData[24] imData[25] imData[26] imData[27] imData[28] imData[29]
+ imData[2] imData[30] imData[31] imData[3] imData[4] imData[5] imData[6] imData[7]
+ imData[8] imData[9] regAddr[0] regAddr[1] regAddr[2] regAddr[3] regAddr[4] regData[0]
+ regData[10] regData[11] regData[12] regData[13] regData[14] regData[15] regData[16]
+ regData[17] regData[18] regData[19] regData[1] regData[20] regData[21] regData[22]
+ regData[23] regData[24] regData[25] regData[26] regData[27] regData[28] regData[29]
+ regData[2] regData[30] regData[31] regData[3] regData[4] regData[5] regData[6] regData[7]
+ regData[8] regData[9] rst_n VPWR VGND
XFILLER_55_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7963_ _8445_/Q _8317_/Q _8381_/Q _8573_/Q _7990_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7963_/X sky130_fd_sc_hd__mux4_1
XFILLER_94_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6914_ _6913_/X _6942_/X _6939_/S VGND VGND VPWR VPWR _6914_/X sky130_fd_sc_hd__mux2_1
XFILLER_54_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7894_ _8538_/Q _8922_/Q _8858_/Q _8890_/Q _7894_/S0 _7897_/S1 VGND VGND VPWR VPWR
+ _7894_/X sky130_fd_sc_hd__mux4_1
XFILLER_23_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6845_ _5871_/Y _7006_/X _6943_/S VGND VGND VPWR VPWR _6845_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3988_ _3989_/A _3988_/B _3988_/C _3988_/D VGND VGND VPWR VPWR _5956_/A sky130_fd_sc_hd__or4_4
XFILLER_10_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6776_ _6347_/Y _6338_/Y _6777_/S VGND VGND VPWR VPWR _9086_/D sky130_fd_sc_hd__mux2_1
X_8515_ _8932_/CLK _8515_/D VGND VGND VPWR VPWR _8515_/Q sky130_fd_sc_hd__dfxtp_1
X_5727_ _5763_/A VGND VGND VPWR VPWR _5742_/A sky130_fd_sc_hd__buf_4
XFILLER_50_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8446_ _8669_/CLK _8446_/D VGND VGND VPWR VPWR _8446_/Q sky130_fd_sc_hd__dfxtp_1
X_5658_ _8108_/Q _5652_/X _5452_/X _5653_/X VGND VGND VPWR VPWR _8108_/D sky130_fd_sc_hd__a22o_1
XFILLER_124_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5589_ _8155_/Q _5581_/X _5416_/X _5584_/X VGND VGND VPWR VPWR _8155_/D sky130_fd_sc_hd__a22o_1
X_4609_ _4609_/A VGND VGND VPWR VPWR _4609_/X sky130_fd_sc_hd__clkbuf_2
X_8377_ _8953_/CLK _8377_/D VGND VGND VPWR VPWR _8377_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_123_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7328_ _8281_/Q _8249_/Q _8217_/Q _9017_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7328_/X sky130_fd_sc_hd__mux4_1
XFILLER_131_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7259_ _8114_/Q _8082_/Q _8050_/Q _9042_/Q _7288_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7259_/X sky130_fd_sc_hd__mux4_2
XFILLER_89_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrepeater190 _7374_/S0 VGND VGND VPWR VPWR _6343_/A sky130_fd_sc_hd__buf_8
XFILLER_93_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4960_ _8532_/Q _4957_/X _4890_/X _4958_/X VGND VGND VPWR VPWR _8532_/D sky130_fd_sc_hd__a22o_1
XFILLER_45_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4891_ _8564_/Q _4886_/X _4890_/X _4888_/X VGND VGND VPWR VPWR _8564_/D sky130_fd_sc_hd__a22o_1
XFILLER_20_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6630_ _6509_/Y _6004_/A _6511_/B _6615_/X VGND VGND VPWR VPWR _6630_/X sky130_fd_sc_hd__o22a_1
X_6561_ _5982_/A _6073_/Y _6438_/X VGND VGND VPWR VPWR _6561_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_32_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8300_ _8780_/CLK _8300_/D VGND VGND VPWR VPWR _8300_/Q sky130_fd_sc_hd__dfxtp_1
X_5512_ _8206_/Q _5508_/X _5448_/X _5509_/X VGND VGND VPWR VPWR _8206_/D sky130_fd_sc_hd__a22o_1
X_6492_ _6827_/X _6002_/X _6491_/X VGND VGND VPWR VPWR _6536_/A sky130_fd_sc_hd__a21bo_1
X_8231_ _9000_/CLK _8231_/D VGND VGND VPWR VPWR _8231_/Q sky130_fd_sc_hd__dfxtp_1
X_5443_ _6794_/X VGND VGND VPWR VPWR _5443_/X sky130_fd_sc_hd__clkbuf_2
X_8162_ _9029_/CLK _8162_/D VGND VGND VPWR VPWR _8162_/Q sky130_fd_sc_hd__dfxtp_1
X_5374_ _5374_/A VGND VGND VPWR VPWR _5374_/X sky130_fd_sc_hd__buf_2
X_7113_ _8420_/Q _8292_/Q _8356_/Q _8548_/Q _7179_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7113_/X sky130_fd_sc_hd__mux4_1
X_4325_ _8891_/Q _4313_/X _4324_/X _4316_/X VGND VGND VPWR VPWR _8891_/D sky130_fd_sc_hd__a22o_1
XFILLER_87_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8093_ _8725_/CLK _8093_/D VGND VGND VPWR VPWR _8093_/Q sky130_fd_sc_hd__dfxtp_1
X_4256_ _8931_/Q _4251_/X _4094_/X _4252_/X VGND VGND VPWR VPWR _8931_/D sky130_fd_sc_hd__a22o_1
X_7044_ _7856_/X _7861_/X _7059_/S VGND VGND VPWR VPWR _7044_/X sky130_fd_sc_hd__mux2_1
X_4187_ _8976_/Q _4185_/X _4049_/X _4186_/X VGND VGND VPWR VPWR _8976_/D sky130_fd_sc_hd__a22o_1
XFILLER_83_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8995_ _9027_/CLK _8995_/D VGND VGND VPWR VPWR _8995_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_43_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7946_ _7942_/X _7943_/X _7944_/X _7945_/X _8006_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _7946_/X sky130_fd_sc_hd__mux4_2
XPHY_2216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7877_ _8601_/Q _8153_/Q _8505_/Q _8793_/Q _7900_/S0 _7900_/S1 VGND VGND VPWR VPWR
+ _7877_/X sky130_fd_sc_hd__mux4_1
XPHY_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6828_ _6651_/X _7027_/X _6830_/S VGND VGND VPWR VPWR _6828_/X sky130_fd_sc_hd__mux2_2
XPHY_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6759_ _6390_/X _6236_/Y _6777_/S VGND VGND VPWR VPWR _9069_/D sky130_fd_sc_hd__mux2_1
XFILLER_136_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8429_ _8940_/CLK _8429_/D VGND VGND VPWR VPWR _8429_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_12_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5090_ _8446_/Q _5085_/X _4866_/X _5088_/X VGND VGND VPWR VPWR _8446_/D sky130_fd_sc_hd__a22o_1
X_4110_ _6809_/X VGND VGND VPWR VPWR _4668_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_110_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4041_ _9043_/Q _4034_/X _4040_/X _4037_/X VGND VGND VPWR VPWR _9043_/D sky130_fd_sc_hd__a22o_1
XFILLER_37_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8780_ _8780_/CLK _8780_/D VGND VGND VPWR VPWR _8780_/Q sky130_fd_sc_hd__dfxtp_1
X_5992_ _5992_/A _5992_/B _5992_/C VGND VGND VPWR VPWR _5992_/X sky130_fd_sc_hd__and3_1
X_7800_ _8981_/Q _8405_/Q _8181_/Q _8757_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7800_/X sky130_fd_sc_hd__mux4_1
X_4943_ _4979_/A VGND VGND VPWR VPWR _4958_/A sky130_fd_sc_hd__clkbuf_4
X_7731_ _7727_/X _7728_/X _7729_/X _7730_/X _7811_/S0 _5873_/B VGND VGND VPWR VPWR
+ _7731_/X sky130_fd_sc_hd__mux4_2
XFILLER_33_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7662_ _8814_/Q _8334_/Q _8942_/Q _8462_/Q _7665_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7662_/X sky130_fd_sc_hd__mux4_1
XFILLER_60_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4874_ _4886_/A VGND VGND VPWR VPWR _4874_/X sky130_fd_sc_hd__clkbuf_2
X_6613_ _7042_/X _6612_/Y _6460_/B VGND VGND VPWR VPWR _6613_/Y sky130_fd_sc_hd__o21ai_1
X_7593_ _8427_/Q _8299_/Q _8363_/Q _8555_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7593_/X sky130_fd_sc_hd__mux4_2
Xclkbuf_4_12_0_clk clkbuf_3_6_0_clk/X VGND VGND VPWR VPWR _9063_/CLK sky130_fd_sc_hd__clkbuf_1
X_6544_ _6544_/A VGND VGND VPWR VPWR _6544_/Y sky130_fd_sc_hd__inv_2
X_6475_ _6475_/A VGND VGND VPWR VPWR _6475_/Y sky130_fd_sc_hd__inv_2
X_5426_ _6801_/X VGND VGND VPWR VPWR _5426_/X sky130_fd_sc_hd__clkbuf_2
X_8214_ _9048_/CLK _8214_/D VGND VGND VPWR VPWR _8214_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_102_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5357_ _5373_/A VGND VGND VPWR VPWR _5357_/X sky130_fd_sc_hd__clkbuf_2
X_8145_ _9009_/CLK _8145_/D VGND VGND VPWR VPWR _8145_/Q sky130_fd_sc_hd__dfxtp_1
X_4308_ _8898_/Q _4302_/X _4097_/X _4303_/X VGND VGND VPWR VPWR _8898_/D sky130_fd_sc_hd__a22o_1
X_8076_ _9004_/CLK _8076_/D VGND VGND VPWR VPWR _8076_/Q sky130_fd_sc_hd__dfxtp_1
X_5288_ _8334_/Q _5284_/X _5176_/X _5285_/X VGND VGND VPWR VPWR _8334_/D sky130_fd_sc_hd__a22o_1
XFILLER_114_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7027_ _6592_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7027_/X sky130_fd_sc_hd__mux2_2
X_4239_ _8944_/Q _4237_/X _4049_/X _4238_/X VGND VGND VPWR VPWR _8944_/D sky130_fd_sc_hd__a22o_1
XFILLER_74_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8978_ _9044_/CLK _8978_/D VGND VGND VPWR VPWR _8978_/Q sky130_fd_sc_hd__dfxtp_1
X_7929_ _8123_/Q _8091_/Q _8059_/Q _9051_/Q _7949_/S0 input9/X VGND VGND VPWR VPWR
+ _7929_/X sky130_fd_sc_hd__mux4_1
XPHY_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_2035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_2057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_2079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4590_ _4651_/A VGND VGND VPWR VPWR _4615_/A sky130_fd_sc_hd__buf_4
XPHY_1890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6260_ _6257_/A _6305_/A _6257_/X _6259_/Y VGND VGND VPWR VPWR _6261_/C sky130_fd_sc_hd__a22o_1
XFILLER_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_1_0_clk clkbuf_3_1_0_clk/A VGND VGND VPWR VPWR clkbuf_4_3_0_clk/A sky130_fd_sc_hd__clkbuf_1
XFILLER_103_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5211_ _5250_/A VGND VGND VPWR VPWR _5229_/A sky130_fd_sc_hd__clkbuf_4
X_6191_ _6201_/A _6191_/B VGND VGND VPWR VPWR _6191_/X sky130_fd_sc_hd__or2_2
X_5142_ _6806_/X VGND VGND VPWR VPWR _5142_/X sky130_fd_sc_hd__clkbuf_2
X_5073_ _8455_/Q _5067_/X _4920_/X _5068_/X VGND VGND VPWR VPWR _8455_/D sky130_fd_sc_hd__a22o_1
XFILLER_111_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8901_ _8933_/CLK _8901_/D VGND VGND VPWR VPWR _8901_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4024_ _9048_/Q _4017_/X _4023_/X _4020_/X VGND VGND VPWR VPWR _9048_/D sky130_fd_sc_hd__a22o_1
XFILLER_92_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8832_ _8928_/CLK _8832_/D VGND VGND VPWR VPWR _8832_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_92_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8763_ _8991_/CLK _8763_/D VGND VGND VPWR VPWR _8763_/Q sky130_fd_sc_hd__dfxtp_1
X_5975_ _7048_/X _6482_/A _7051_/X _5974_/Y VGND VGND VPWR VPWR _5976_/B sky130_fd_sc_hd__a22o_1
X_4926_ _6783_/X VGND VGND VPWR VPWR _4926_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_21_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8694_ _8757_/CLK _8694_/D VGND VGND VPWR VPWR _8694_/Q sky130_fd_sc_hd__dfxtp_1
X_7714_ _8529_/Q _8913_/Q _8849_/Q _8881_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7714_/X sky130_fd_sc_hd__mux4_1
X_7645_ _8717_/Q _8685_/Q _8653_/Q _8621_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7645_/X sky130_fd_sc_hd__mux4_2
X_4857_ _8576_/Q _4828_/A _4663_/X _4829_/A VGND VGND VPWR VPWR _8576_/D sky130_fd_sc_hd__a22o_1
XFILLER_21_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7576_ _7572_/X _7573_/X _7574_/X _7575_/X _5771_/C _7601_/S1 VGND VGND VPWR VPWR
+ _7576_/X sky130_fd_sc_hd__mux4_2
X_4788_ _4802_/A VGND VGND VPWR VPWR _4788_/X sky130_fd_sc_hd__buf_2
X_6527_ _6513_/C _6513_/D _5835_/Y _6526_/Y VGND VGND VPWR VPWR _6528_/B sky130_fd_sc_hd__o31a_1
XFILLER_118_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6458_ _6458_/A _6458_/B VGND VGND VPWR VPWR _6612_/B sky130_fd_sc_hd__or2_2
X_5409_ _8255_/Q _5405_/X _5213_/X _5408_/X VGND VGND VPWR VPWR _8255_/D sky130_fd_sc_hd__a22o_1
X_6389_ _6385_/A _6379_/Y _6241_/Y VGND VGND VPWR VPWR _6389_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_121_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8128_ _9024_/CLK _8128_/D VGND VGND VPWR VPWR _8128_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_102_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8059_ _9051_/CLK _8059_/D VGND VGND VPWR VPWR _8059_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_90_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5760_ _8040_/Q _5755_/X _4645_/A _5756_/X VGND VGND VPWR VPWR _8040_/D sky130_fd_sc_hd__a22o_1
XFILLER_34_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4711_ _8674_/Q _4705_/X _4659_/X _4706_/X VGND VGND VPWR VPWR _8674_/D sky130_fd_sc_hd__a22o_1
X_5691_ _8087_/Q _5686_/X _4609_/A _5687_/X VGND VGND VPWR VPWR _8087_/D sky130_fd_sc_hd__a22o_1
X_4642_ _8714_/Q _4637_/X _4641_/X _4639_/X VGND VGND VPWR VPWR _8714_/D sky130_fd_sc_hd__a22o_1
X_7430_ _8962_/Q _8386_/Q _8162_/Q _8738_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7430_/X sky130_fd_sc_hd__mux4_1
XFILLER_30_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4573_ _8745_/Q _4569_/X _4368_/X _4570_/X VGND VGND VPWR VPWR _8745_/D sky130_fd_sc_hd__a22o_1
X_7361_ _7357_/X _7358_/X _7359_/X _7360_/X _7391_/S0 _6343_/B VGND VGND VPWR VPWR
+ _7361_/X sky130_fd_sc_hd__mux4_1
XFILLER_115_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6312_ _6329_/A _6226_/A _6227_/Y _6232_/X _6311_/X VGND VGND VPWR VPWR _6312_/X
+ sky130_fd_sc_hd__o221a_1
X_7292_ _8822_/Q _8342_/Q _8950_/Q _8470_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7292_/X sky130_fd_sc_hd__mux4_1
X_9031_ _9031_/CLK _9031_/D VGND VGND VPWR VPWR _9031_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_103_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6243_ _6311_/A _6311_/B _6388_/A _6385_/A VGND VGND VPWR VPWR _6309_/A sky130_fd_sc_hd__or4_4
XFILLER_131_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6174_ _9086_/Q _6171_/B _6171_/Y VGND VGND VPWR VPWR _6338_/A sky130_fd_sc_hd__o21ai_2
X_5125_ _8421_/Q _5122_/X _4926_/X _5123_/X VGND VGND VPWR VPWR _8421_/D sky130_fd_sc_hd__a22o_1
XFILLER_84_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5056_ _8468_/Q _5053_/X _4890_/X _5054_/X VGND VGND VPWR VPWR _8468_/D sky130_fd_sc_hd__a22o_1
XFILLER_72_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4007_ _9053_/Q _3998_/X _4006_/X _4003_/X VGND VGND VPWR VPWR _9053_/D sky130_fd_sc_hd__a22o_1
XFILLER_65_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8815_ _8943_/CLK _8815_/D VGND VGND VPWR VPWR _8815_/Q sky130_fd_sc_hd__dfxtp_1
X_8746_ _8970_/CLK _8746_/D VGND VGND VPWR VPWR _8746_/Q sky130_fd_sc_hd__dfxtp_1
X_5958_ _5958_/A VGND VGND VPWR VPWR _6621_/A sky130_fd_sc_hd__inv_2
XFILLER_40_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4909_ _8556_/Q _4898_/X _4908_/X _4900_/X VGND VGND VPWR VPWR _8556_/D sky130_fd_sc_hd__a22o_1
XFILLER_139_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8677_ _8709_/CLK _8677_/D VGND VGND VPWR VPWR _8677_/Q sky130_fd_sc_hd__dfxtp_1
X_5889_ _5889_/A VGND VGND VPWR VPWR _5889_/X sky130_fd_sc_hd__clkbuf_1
XFILLER_138_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7628_ _8268_/Q _8236_/Q _8204_/Q _9004_/Q _7665_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7628_/X sky130_fd_sc_hd__mux4_1
X_7559_ _8105_/Q _8073_/Q _8041_/Q _9033_/Q _7600_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7559_/X sky130_fd_sc_hd__mux4_2
XFILLER_134_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_5 _4651_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6930_ _7030_/X _7033_/X _6963_/S VGND VGND VPWR VPWR _6930_/X sky130_fd_sc_hd__mux2_1
XFILLER_19_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6861_ _5910_/X _6994_/X _6943_/S VGND VGND VPWR VPWR _6861_/X sky130_fd_sc_hd__mux2_1
X_5812_ _5812_/A VGND VGND VPWR VPWR _5813_/A sky130_fd_sc_hd__inv_2
XFILLER_90_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6792_ _6665_/Y _6663_/Y _6809_/S VGND VGND VPWR VPWR _6792_/X sky130_fd_sc_hd__mux2_2
XFILLER_62_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8600_ _8952_/CLK _8600_/D VGND VGND VPWR VPWR _8600_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_50_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5743_ _8053_/Q _5741_/X _4614_/A _5742_/X VGND VGND VPWR VPWR _8053_/D sky130_fd_sc_hd__a22o_1
X_8531_ _8882_/CLK _8531_/D VGND VGND VPWR VPWR _8531_/Q sky130_fd_sc_hd__dfxtp_1
X_8462_ _8941_/CLK _8462_/D VGND VGND VPWR VPWR _8462_/Q sky130_fd_sc_hd__dfxtp_1
X_5674_ _8096_/Q _5645_/A _5480_/X _5646_/A VGND VGND VPWR VPWR _8096_/D sky130_fd_sc_hd__a22o_1
XFILLER_136_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8393_ _8970_/CLK _8393_/D VGND VGND VPWR VPWR _8393_/Q sky130_fd_sc_hd__dfxtp_1
X_7413_ _8418_/Q _8290_/Q _8354_/Q _8546_/Q _7480_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7413_/X sky130_fd_sc_hd__mux4_1
X_4625_ _4649_/A VGND VGND VPWR VPWR _4625_/X sky130_fd_sc_hd__clkbuf_2
X_7344_ _8539_/Q _8923_/Q _8859_/Q _8891_/Q _7390_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7344_/X sky130_fd_sc_hd__mux4_2
X_4556_ _4556_/A VGND VGND VPWR VPWR _4556_/X sky130_fd_sc_hd__buf_2
XFILLER_116_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4487_ _8800_/Q _4458_/A _4388_/X _4459_/A VGND VGND VPWR VPWR _8800_/D sky130_fd_sc_hd__a22o_1
X_7275_ _8724_/Q _8692_/Q _8660_/Q _8628_/Q _7288_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7275_/X sky130_fd_sc_hd__mux4_1
XFILLER_1_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_9014_ _9014_/CLK _9014_/D VGND VGND VPWR VPWR _9014_/Q sky130_fd_sc_hd__dfxtp_1
X_6226_ _6226_/A VGND VGND VPWR VPWR _6227_/B sky130_fd_sc_hd__inv_2
XFILLER_100_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6157_ _9079_/Q _6157_/B VGND VGND VPWR VPWR _6158_/A sky130_fd_sc_hd__nand2_1
XFILLER_85_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5108_ _5122_/A VGND VGND VPWR VPWR _5108_/X sky130_fd_sc_hd__buf_2
XFILLER_57_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6088_ _5947_/A _5858_/B _5859_/B VGND VGND VPWR VPWR _6088_/X sky130_fd_sc_hd__a21o_1
XFILLER_73_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5039_ _5075_/A VGND VGND VPWR VPWR _5054_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_73_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8729_ _8729_/CLK _8729_/D VGND VGND VPWR VPWR _8729_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_114_clk clkbuf_4_0_0_clk/X VGND VGND VPWR VPWR _8981_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_5_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xoutput42 _9068_/Q VGND VGND VPWR VPWR imAddr[12] sky130_fd_sc_hd__clkbuf_2
Xoutput64 _9059_/Q VGND VGND VPWR VPWR imAddr[3] sky130_fd_sc_hd__clkbuf_2
Xoutput75 _6709_/X VGND VGND VPWR VPWR regData[13] sky130_fd_sc_hd__clkbuf_2
XFILLER_1_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xoutput53 _9078_/Q VGND VGND VPWR VPWR imAddr[22] sky130_fd_sc_hd__clkbuf_2
Xoutput86 _6729_/X VGND VGND VPWR VPWR regData[23] sky130_fd_sc_hd__clkbuf_2
Xoutput97 _6691_/X VGND VGND VPWR VPWR regData[4] sky130_fd_sc_hd__clkbuf_2
XFILLER_49_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_105_clk clkbuf_4_2_0_clk/X VGND VGND VPWR VPWR _8757_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4410_ _4410_/A VGND VGND VPWR VPWR _4410_/X sky130_fd_sc_hd__clkbuf_2
X_5390_ _8266_/Q _5387_/X _5186_/X _5388_/X VGND VGND VPWR VPWR _8266_/D sky130_fd_sc_hd__a22o_1
X_4341_ _8885_/Q _4338_/X _4339_/X _4340_/X VGND VGND VPWR VPWR _8885_/D sky130_fd_sc_hd__a22o_1
X_4272_ _8924_/Q _4265_/X _4009_/X _4268_/X VGND VGND VPWR VPWR _8924_/D sky130_fd_sc_hd__a22o_1
X_7060_ _6354_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7060_/X sky130_fd_sc_hd__mux2_2
XFILLER_4_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6011_ _7024_/X _6008_/X _7021_/X _6010_/Y VGND VGND VPWR VPWR _6011_/X sky130_fd_sc_hd__o22a_1
XFILLER_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7962_ _8829_/Q _8349_/Q _8957_/Q _8477_/Q _7990_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7962_/X sky130_fd_sc_hd__mux4_1
XFILLER_27_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6913_ _6976_/X _6979_/X _6963_/S VGND VGND VPWR VPWR _6913_/X sky130_fd_sc_hd__mux2_1
X_7893_ _8442_/Q _8314_/Q _8378_/Q _8570_/Q _7894_/S0 _7897_/S1 VGND VGND VPWR VPWR
+ _7893_/X sky130_fd_sc_hd__mux4_1
X_6844_ _6843_/X _6121_/X _6948_/S VGND VGND VPWR VPWR _6844_/X sky130_fd_sc_hd__mux2_1
XPHY_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3987_ _6288_/A _3989_/B _3989_/C VGND VGND VPWR VPWR _5958_/A sky130_fd_sc_hd__or3_4
XFILLER_22_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6775_ _6346_/Y _6184_/Y _6777_/S VGND VGND VPWR VPWR _9085_/D sky130_fd_sc_hd__mux2_1
X_8514_ _8934_/CLK _8514_/D VGND VGND VPWR VPWR _8514_/Q sky130_fd_sc_hd__dfxtp_1
X_5726_ _5762_/A VGND VGND VPWR VPWR _5763_/A sky130_fd_sc_hd__inv_2
X_8445_ _8863_/CLK _8445_/D VGND VGND VPWR VPWR _8445_/Q sky130_fd_sc_hd__dfxtp_1
X_5657_ _8109_/Q _5652_/X _5450_/X _5653_/X VGND VGND VPWR VPWR _8109_/D sky130_fd_sc_hd__a22o_1
X_5588_ _8156_/Q _5581_/X _5414_/X _5584_/X VGND VGND VPWR VPWR _8156_/D sky130_fd_sc_hd__a22o_1
X_8376_ _8757_/CLK _8376_/D VGND VGND VPWR VPWR _8376_/Q sky130_fd_sc_hd__dfxtp_1
X_4608_ _8728_/Q _4601_/X _4607_/X _4603_/X VGND VGND VPWR VPWR _8728_/D sky130_fd_sc_hd__a22o_1
X_4539_ _4555_/A VGND VGND VPWR VPWR _4539_/X sky130_fd_sc_hd__clkbuf_2
X_7327_ _8601_/Q _8153_/Q _8505_/Q _8793_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7327_/X sky130_fd_sc_hd__mux4_1
XFILLER_131_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7258_ _8274_/Q _8242_/Q _8210_/Q _9010_/Q _7280_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7258_/X sky130_fd_sc_hd__mux4_2
XFILLER_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6209_ _6176_/A _6207_/Y _6208_/X VGND VGND VPWR VPWR _6214_/A sky130_fd_sc_hd__o21ai_2
XFILLER_131_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7189_ _8107_/Q _8075_/Q _8043_/Q _9035_/Q _7190_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7189_/X sky130_fd_sc_hd__mux4_1
XFILLER_58_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater180 _7135_/S0 VGND VGND VPWR VPWR _7130_/S0 sky130_fd_sc_hd__buf_6
XFILLER_18_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater191 _7185_/S0 VGND VGND VPWR VPWR _7374_/S0 sky130_fd_sc_hd__buf_8
XFILLER_45_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4890_ _6798_/X VGND VGND VPWR VPWR _4890_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_44_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6560_ _6560_/A VGND VGND VPWR VPWR _6560_/X sky130_fd_sc_hd__buf_1
XFILLER_32_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5511_ _8207_/Q _5508_/X _5446_/X _5509_/X VGND VGND VPWR VPWR _8207_/D sky130_fd_sc_hd__a22o_1
X_6491_ _6827_/X _6491_/B VGND VGND VPWR VPWR _6491_/X sky130_fd_sc_hd__or2_1
X_8230_ _9028_/CLK _8230_/D VGND VGND VPWR VPWR _8230_/Q sky130_fd_sc_hd__dfxtp_1
X_5442_ _5466_/A VGND VGND VPWR VPWR _5442_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_126_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8161_ _9054_/CLK _8161_/D VGND VGND VPWR VPWR _8161_/Q sky130_fd_sc_hd__dfxtp_1
X_5373_ _5373_/A VGND VGND VPWR VPWR _5373_/X sky130_fd_sc_hd__buf_2
X_7112_ _8804_/Q _8324_/Q _8932_/Q _8452_/Q _7179_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7112_/X sky130_fd_sc_hd__mux4_1
X_4324_ _4599_/A VGND VGND VPWR VPWR _4324_/X sky130_fd_sc_hd__clkbuf_2
X_8092_ _9051_/CLK _8092_/D VGND VGND VPWR VPWR _8092_/Q sky130_fd_sc_hd__dfxtp_1
X_7043_ _7846_/X _7851_/X _7070_/S VGND VGND VPWR VPWR _7043_/X sky130_fd_sc_hd__mux2_2
XFILLER_113_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4255_ _8932_/Q _4251_/X _4091_/X _4252_/X VGND VGND VPWR VPWR _8932_/D sky130_fd_sc_hd__a22o_1
X_4186_ _4200_/A VGND VGND VPWR VPWR _4186_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_95_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8994_ _8994_/CLK _8994_/D VGND VGND VPWR VPWR _8994_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_67_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7945_ _8732_/Q _8700_/Q _8668_/Q _8636_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _7945_/X sky130_fd_sc_hd__mux4_2
XFILLER_36_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7876_ _7872_/X _7873_/X _7874_/X _7875_/X _7901_/S0 _8031_/S1 VGND VGND VPWR VPWR
+ _7876_/X sky130_fd_sc_hd__mux4_1
XFILLER_35_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6827_ _6641_/X _7030_/X _6830_/S VGND VGND VPWR VPWR _6827_/X sky130_fd_sc_hd__mux2_1
XPHY_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6758_ _6386_/X _6241_/B _6777_/S VGND VGND VPWR VPWR _9068_/D sky130_fd_sc_hd__mux2_1
X_6689_ _6688_/X _9059_/Q _6741_/S VGND VGND VPWR VPWR _6689_/X sky130_fd_sc_hd__mux2_1
XFILLER_109_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5709_ _8075_/Q _5707_/X _4638_/A _5708_/X VGND VGND VPWR VPWR _8075_/D sky130_fd_sc_hd__a22o_1
X_8428_ _8994_/CLK _8428_/D VGND VGND VPWR VPWR _8428_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_128_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8359_ _8456_/CLK _8359_/D VGND VGND VPWR VPWR _8359_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_128_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4040_ _4619_/A VGND VGND VPWR VPWR _4040_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_83_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5991_ _7051_/X _5974_/Y _5988_/X _5990_/X VGND VGND VPWR VPWR _5992_/C sky130_fd_sc_hd__o211a_1
XFILLER_18_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4942_ _4978_/A VGND VGND VPWR VPWR _4979_/A sky130_fd_sc_hd__clkinv_4
XFILLER_52_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7730_ _8977_/Q _8401_/Q _8177_/Q _8753_/Q _7885_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7730_/X sky130_fd_sc_hd__mux4_1
XFILLER_24_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7661_ _7657_/X _7658_/X _7659_/X _7660_/X _7701_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7661_/X sky130_fd_sc_hd__mux4_1
X_4873_ _8571_/Q _4861_/X _4872_/X _4864_/X VGND VGND VPWR VPWR _8571_/D sky130_fd_sc_hd__a22o_1
X_6612_ _6612_/A _6612_/B VGND VGND VPWR VPWR _6612_/Y sky130_fd_sc_hd__nor2_1
X_7592_ _8811_/Q _8331_/Q _8939_/Q _8459_/Q _7594_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7592_/X sky130_fd_sc_hd__mux4_1
XFILLER_20_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6543_ _6825_/X _5999_/X _6542_/X VGND VGND VPWR VPWR _6544_/A sky130_fd_sc_hd__o21ai_2
XFILLER_118_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6474_ _6473_/Y _5970_/A _6818_/X _5970_/Y VGND VGND VPWR VPWR _6475_/A sky130_fd_sc_hd__o22a_1
XFILLER_118_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5425_ _8248_/Q _5418_/X _5424_/X _5420_/X VGND VGND VPWR VPWR _8248_/D sky130_fd_sc_hd__a22o_1
X_8213_ _8981_/CLK _8213_/D VGND VGND VPWR VPWR _8213_/Q sky130_fd_sc_hd__dfxtp_1
X_5356_ _5394_/A VGND VGND VPWR VPWR _5373_/A sky130_fd_sc_hd__buf_4
X_8144_ _8975_/CLK _8144_/D VGND VGND VPWR VPWR _8144_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_114_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4307_ _8899_/Q _4302_/X _4094_/X _4303_/X VGND VGND VPWR VPWR _8899_/D sky130_fd_sc_hd__a22o_1
X_8075_ _9035_/CLK _8075_/D VGND VGND VPWR VPWR _8075_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5287_ _8335_/Q _5284_/X _5174_/X _5285_/X VGND VGND VPWR VPWR _8335_/D sky130_fd_sc_hd__a22o_1
XFILLER_87_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4238_ _4252_/A VGND VGND VPWR VPWR _4238_/X sky130_fd_sc_hd__buf_2
X_7026_ _7736_/X _7741_/X _7059_/S VGND VGND VPWR VPWR _7026_/X sky130_fd_sc_hd__mux2_2
XFILLER_101_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4169_ _8988_/Q _4162_/X _4009_/X _4165_/X VGND VGND VPWR VPWR _8988_/D sky130_fd_sc_hd__a22o_1
XFILLER_55_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_94_clk clkbuf_4_8_0_clk/X VGND VGND VPWR VPWR _9049_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_83_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8977_ _9009_/CLK _8977_/D VGND VGND VPWR VPWR _8977_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_82_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7928_ _8283_/Q _8251_/Q _8219_/Q _9019_/Q _7949_/S0 input9/X VGND VGND VPWR VPWR
+ _7928_/X sky130_fd_sc_hd__mux4_1
XFILLER_55_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_2025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7859_ _8120_/Q _8088_/Q _8056_/Q _9048_/Q input14/X _7900_/S1 VGND VGND VPWR VPWR
+ _7859_/X sky130_fd_sc_hd__mux4_2
XPHY_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_85_clk _8944_/CLK VGND VGND VPWR VPWR _8943_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_19_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5210_ _5210_/A _5307_/B VGND VGND VPWR VPWR _5250_/A sky130_fd_sc_hd__or2_4
XFILLER_130_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6190_ _6217_/A VGND VGND VPWR VPWR _6201_/A sky130_fd_sc_hd__buf_1
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5141_ _8413_/Q _5133_/X _5140_/X _5136_/X VGND VGND VPWR VPWR _8413_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5072_ _8456_/Q _5067_/X _4918_/X _5068_/X VGND VGND VPWR VPWR _8456_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8900_ _8932_/CLK _8900_/D VGND VGND VPWR VPWR _8900_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_97_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4023_ _4607_/A VGND VGND VPWR VPWR _4023_/X sky130_fd_sc_hd__clkbuf_2
Xclkbuf_leaf_76_clk clkbuf_opt_0_clk/A VGND VGND VPWR VPWR _9067_/CLK sky130_fd_sc_hd__clkbuf_16
X_8831_ _8959_/CLK _8831_/D VGND VGND VPWR VPWR _8831_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8762_ _8986_/CLK _8762_/D VGND VGND VPWR VPWR _8762_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_25_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5974_ _5974_/A VGND VGND VPWR VPWR _5974_/Y sky130_fd_sc_hd__inv_2
X_7713_ _8433_/Q _8305_/Q _8369_/Q _8561_/Q _7798_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7713_/X sky130_fd_sc_hd__mux4_1
X_4925_ _8550_/Q _4922_/X _4923_/X _4924_/X VGND VGND VPWR VPWR _8550_/D sky130_fd_sc_hd__a22o_1
X_8693_ _8725_/CLK _8693_/D VGND VGND VPWR VPWR _8693_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_33_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4856_ _8577_/Q _4828_/A _4661_/X _4829_/A VGND VGND VPWR VPWR _8577_/D sky130_fd_sc_hd__a22o_1
X_7644_ _8525_/Q _8909_/Q _8845_/Q _8877_/Q _7665_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7644_/X sky130_fd_sc_hd__mux4_1
XFILLER_60_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7575_ _8714_/Q _8682_/Q _8650_/Q _8618_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7575_/X sky130_fd_sc_hd__mux4_1
XFILLER_21_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4787_ _4801_/A VGND VGND VPWR VPWR _4787_/X sky130_fd_sc_hd__clkbuf_2
X_6526_ _6845_/X _6101_/B _6525_/X VGND VGND VPWR VPWR _6526_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_118_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6457_ _6457_/A _6457_/B VGND VGND VPWR VPWR _6458_/B sky130_fd_sc_hd__or2_1
X_5408_ _5432_/A VGND VGND VPWR VPWR _5408_/X sky130_fd_sc_hd__buf_2
X_6388_ _6388_/A VGND VGND VPWR VPWR _6388_/Y sky130_fd_sc_hd__inv_2
X_5339_ _5346_/A VGND VGND VPWR VPWR _5339_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_88_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8127_ _9052_/CLK _8127_/D VGND VGND VPWR VPWR _8127_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_102_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8058_ _9078_/CLK _8058_/D VGND VGND VPWR VPWR _8058_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_29_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_67_clk clkbuf_4_14_0_clk/X VGND VGND VPWR VPWR _8780_/CLK sky130_fd_sc_hd__clkbuf_16
X_7009_ _6670_/Y _6387_/Y _7069_/S VGND VGND VPWR VPWR _7009_/X sky130_fd_sc_hd__mux2_4
XFILLER_28_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_58_clk clkbuf_4_15_0_clk/X VGND VGND VPWR VPWR _8869_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_94_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_11_0_clk clkbuf_3_5_0_clk/X VGND VGND VPWR VPWR clkbuf_4_11_0_clk/X sky130_fd_sc_hd__clkbuf_1
XFILLER_35_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4710_ _8675_/Q _4705_/X _4657_/X _4706_/X VGND VGND VPWR VPWR _8675_/D sky130_fd_sc_hd__a22o_1
X_5690_ _8088_/Q _5686_/X _4607_/A _5687_/X VGND VGND VPWR VPWR _8088_/D sky130_fd_sc_hd__a22o_1
X_4641_ _4641_/A VGND VGND VPWR VPWR _4641_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_128_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4572_ _8746_/Q _4569_/X _4366_/X _4570_/X VGND VGND VPWR VPWR _8746_/D sky130_fd_sc_hd__a22o_1
X_7360_ _8988_/Q _8412_/Q _8188_/Q _8764_/Q _7390_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7360_/X sky130_fd_sc_hd__mux4_1
XFILLER_116_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7291_ _7287_/X _7288_/X _7289_/X _7290_/X _7291_/S0 _7336_/S1 VGND VGND VPWR VPWR
+ _7291_/X sky130_fd_sc_hd__mux4_2
X_6311_ _6311_/A _6311_/B _6311_/C VGND VGND VPWR VPWR _6311_/X sky130_fd_sc_hd__or3_1
XFILLER_115_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_9030_ _9061_/CLK _9030_/D VGND VGND VPWR VPWR _9030_/Q sky130_fd_sc_hd__dfxtp_1
X_6242_ input4/X _6241_/B _6241_/Y VGND VGND VPWR VPWR _6385_/A sky130_fd_sc_hd__o21ai_4
XFILLER_69_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6173_ _6173_/A VGND VGND VPWR VPWR _6173_/Y sky130_fd_sc_hd__inv_2
X_5124_ _8422_/Q _5122_/X _4923_/X _5123_/X VGND VGND VPWR VPWR _8422_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_49_clk clkbuf_4_13_0_clk/X VGND VGND VPWR VPWR _8970_/CLK sky130_fd_sc_hd__clkbuf_16
X_5055_ _8469_/Q _5053_/X _4887_/X _5054_/X VGND VGND VPWR VPWR _8469_/D sky130_fd_sc_hd__a22o_1
X_4006_ _4595_/A VGND VGND VPWR VPWR _4006_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_55_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8814_ _8941_/CLK _8814_/D VGND VGND VPWR VPWR _8814_/Q sky130_fd_sc_hd__dfxtp_1
X_8745_ _8970_/CLK _8745_/D VGND VGND VPWR VPWR _8745_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_111_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5957_ _6284_/A _5956_/A _6430_/A VGND VGND VPWR VPWR _6943_/S sky130_fd_sc_hd__o21ai_4
XFILLER_71_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8676_ _8710_/CLK _8676_/D VGND VGND VPWR VPWR _8676_/Q sky130_fd_sc_hd__dfxtp_1
X_4908_ _6790_/X VGND VGND VPWR VPWR _4908_/X sky130_fd_sc_hd__clkbuf_2
X_7627_ _8588_/Q _8140_/Q _8492_/Q _8780_/Q _7665_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7627_/X sky130_fd_sc_hd__mux4_2
X_5888_ _6433_/A _6950_/X VGND VGND VPWR VPWR _5889_/A sky130_fd_sc_hd__or2_1
XFILLER_138_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4839_ _8590_/Q _4835_/X _4631_/X _4836_/X VGND VGND VPWR VPWR _8590_/D sky130_fd_sc_hd__a22o_1
X_7558_ _8265_/Q _8233_/Q _8201_/Q _9001_/Q _7600_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7558_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7489_ _8101_/Q _8069_/Q _8037_/Q _9029_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7489_/X sky130_fd_sc_hd__mux4_1
X_6509_ _6826_/X VGND VGND VPWR VPWR _6509_/Y sky130_fd_sc_hd__inv_2
XFILLER_136_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_0_0_clk clkbuf_3_1_0_clk/A VGND VGND VPWR VPWR clkbuf_4_1_0_clk/A sky130_fd_sc_hd__clkbuf_1
XFILLER_31_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XANTENNA_6 _4651_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6860_ _6894_/X _6892_/X _6932_/S VGND VGND VPWR VPWR _6860_/X sky130_fd_sc_hd__mux2_1
XFILLER_34_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5811_ _6981_/X _5822_/A VGND VGND VPWR VPWR _5812_/A sky130_fd_sc_hd__nand2_2
X_6791_ _6674_/Y _6672_/Y _6809_/S VGND VGND VPWR VPWR _6791_/X sky130_fd_sc_hd__mux2_2
XFILLER_62_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8530_ _8882_/CLK _8530_/D VGND VGND VPWR VPWR _8530_/Q sky130_fd_sc_hd__dfxtp_1
X_5742_ _5742_/A VGND VGND VPWR VPWR _5742_/X sky130_fd_sc_hd__clkbuf_2
X_5673_ _8097_/Q _5645_/A _5478_/X _5646_/A VGND VGND VPWR VPWR _8097_/D sky130_fd_sc_hd__a22o_1
X_8461_ _8941_/CLK _8461_/D VGND VGND VPWR VPWR _8461_/Q sky130_fd_sc_hd__dfxtp_1
X_7412_ _8802_/Q _8322_/Q _8930_/Q _8450_/Q _7480_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7412_/X sky130_fd_sc_hd__mux4_1
X_8392_ _9000_/CLK _8392_/D VGND VGND VPWR VPWR _8392_/Q sky130_fd_sc_hd__dfxtp_1
X_4624_ _8721_/Q _4613_/X _4623_/X _4615_/X VGND VGND VPWR VPWR _8721_/D sky130_fd_sc_hd__a22o_1
XFILLER_135_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7343_ _8443_/Q _8315_/Q _8379_/Q _8571_/Q _7390_/S0 _6344_/B VGND VGND VPWR VPWR
+ _7343_/X sky130_fd_sc_hd__mux4_2
X_4555_ _4555_/A VGND VGND VPWR VPWR _4555_/X sky130_fd_sc_hd__buf_2
XFILLER_128_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4486_ _8801_/Q _4458_/A _4386_/X _4459_/A VGND VGND VPWR VPWR _8801_/D sky130_fd_sc_hd__a22o_1
XFILLER_89_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7274_ _8532_/Q _8916_/Q _8852_/Q _8884_/Q _7288_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7274_/X sky130_fd_sc_hd__mux4_1
X_9013_ _9013_/CLK _9013_/D VGND VGND VPWR VPWR _9013_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_131_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6225_ _6225_/A _6225_/B VGND VGND VPWR VPWR _6226_/A sky130_fd_sc_hd__or2_1
XFILLER_58_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6156_ _6156_/A VGND VGND VPWR VPWR _6157_/B sky130_fd_sc_hd__inv_2
XFILLER_111_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5107_ _8433_/Q _5101_/X _4896_/X _5102_/X VGND VGND VPWR VPWR _8433_/D sky130_fd_sc_hd__a22o_1
X_6087_ _6948_/X _5946_/A _6110_/C _5954_/X _6086_/X VGND VGND VPWR VPWR _6087_/Y
+ sky130_fd_sc_hd__o221ai_1
X_5038_ _5074_/A VGND VGND VPWR VPWR _5075_/A sky130_fd_sc_hd__clkinv_4
XFILLER_26_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6989_ _7486_/X _7491_/X _7022_/S VGND VGND VPWR VPWR _6989_/X sky130_fd_sc_hd__mux2_2
X_8728_ _8757_/CLK _8728_/D VGND VGND VPWR VPWR _8728_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8659_ _9019_/CLK _8659_/D VGND VGND VPWR VPWR _8659_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput43 _9069_/Q VGND VGND VPWR VPWR imAddr[13] sky130_fd_sc_hd__clkbuf_2
Xoutput76 _6711_/X VGND VGND VPWR VPWR regData[14] sky130_fd_sc_hd__clkbuf_2
Xoutput65 _9060_/Q VGND VGND VPWR VPWR imAddr[4] sky130_fd_sc_hd__clkbuf_2
Xoutput54 _9079_/Q VGND VGND VPWR VPWR imAddr[23] sky130_fd_sc_hd__clkbuf_2
XFILLER_1_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xoutput98 _6693_/X VGND VGND VPWR VPWR regData[5] sky130_fd_sc_hd__clkbuf_2
XFILLER_122_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput87 _6731_/X VGND VGND VPWR VPWR regData[24] sky130_fd_sc_hd__clkbuf_2
XFILLER_0_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4340_ _4340_/A VGND VGND VPWR VPWR _4340_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_113_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4271_ _8925_/Q _4265_/X _4006_/X _4268_/X VGND VGND VPWR VPWR _8925_/D sky130_fd_sc_hd__a22o_1
XFILLER_113_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6010_ _6010_/A VGND VGND VPWR VPWR _6010_/Y sky130_fd_sc_hd__inv_2
XFILLER_79_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7961_ _7957_/X _7958_/X _7959_/X _7960_/X _8031_/S0 _8001_/S1 VGND VGND VPWR VPWR
+ _7961_/X sky130_fd_sc_hd__mux4_1
X_6912_ _5949_/Y _6979_/X _6943_/S VGND VGND VPWR VPWR _6912_/X sky130_fd_sc_hd__mux2_1
XFILLER_82_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7892_ _8826_/Q _8346_/Q _8954_/Q _8474_/Q _7894_/S0 _7897_/S1 VGND VGND VPWR VPWR
+ _7892_/X sky130_fd_sc_hd__mux4_1
XFILLER_47_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6843_ _6893_/X _6890_/X _6918_/S VGND VGND VPWR VPWR _6843_/X sky130_fd_sc_hd__mux2_1
XFILLER_23_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3986_ _3986_/A _3988_/D VGND VGND VPWR VPWR _3989_/C sky130_fd_sc_hd__or2_1
X_6774_ _6349_/Y _6180_/Y _6777_/S VGND VGND VPWR VPWR _9084_/D sky130_fd_sc_hd__mux2_1
X_8513_ _8929_/CLK _8513_/D VGND VGND VPWR VPWR _8513_/Q sky130_fd_sc_hd__dfxtp_1
X_5725_ _5741_/A VGND VGND VPWR VPWR _5725_/X sky130_fd_sc_hd__clkbuf_2
X_8444_ _8731_/CLK _8444_/D VGND VGND VPWR VPWR _8444_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_109_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5656_ _8110_/Q _5652_/X _5448_/X _5653_/X VGND VGND VPWR VPWR _8110_/D sky130_fd_sc_hd__a22o_1
X_4607_ _4607_/A VGND VGND VPWR VPWR _4607_/X sky130_fd_sc_hd__clkbuf_2
X_5587_ _8157_/Q _5581_/X _5412_/X _5584_/X VGND VGND VPWR VPWR _8157_/D sky130_fd_sc_hd__a22o_1
X_8375_ _8665_/CLK _8375_/D VGND VGND VPWR VPWR _8375_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_89_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4538_ _4576_/A VGND VGND VPWR VPWR _4555_/A sky130_fd_sc_hd__clkbuf_4
X_7326_ _7322_/X _7323_/X _7324_/X _7325_/X _7341_/S0 _7336_/S1 VGND VGND VPWR VPWR
+ _7326_/X sky130_fd_sc_hd__mux4_1
XFILLER_132_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4469_ _8814_/Q _4465_/X _4356_/X _4466_/X VGND VGND VPWR VPWR _8814_/D sky130_fd_sc_hd__a22o_1
X_7257_ _8594_/Q _8146_/Q _8498_/Q _8786_/Q _7288_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7257_/X sky130_fd_sc_hd__mux4_1
XFILLER_89_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6208_ _6217_/A _6208_/B VGND VGND VPWR VPWR _6208_/X sky130_fd_sc_hd__or2_2
X_7188_ _8267_/Q _8235_/Q _8203_/Q _9003_/Q _7190_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7188_/X sky130_fd_sc_hd__mux4_1
X_6139_ _6139_/A _6265_/A VGND VGND VPWR VPWR _6144_/C sky130_fd_sc_hd__or2_1
XFILLER_85_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrepeater170 _6344_/B VGND VGND VPWR VPWR _7390_/S1 sky130_fd_sc_hd__buf_8
XFILLER_100_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater181 _7179_/S0 VGND VGND VPWR VPWR _7135_/S0 sky130_fd_sc_hd__buf_6
Xrepeater192 _7184_/S0 VGND VGND VPWR VPWR _7185_/S0 sky130_fd_sc_hd__buf_8
XFILLER_38_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5510_ _8208_/Q _5508_/X _5443_/X _5509_/X VGND VGND VPWR VPWR _8208_/D sky130_fd_sc_hd__a22o_1
XFILLER_118_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6490_ _6490_/A VGND VGND VPWR VPWR _6550_/B sky130_fd_sc_hd__inv_2
X_5441_ _8241_/Q _5430_/X _5440_/X _5432_/X VGND VGND VPWR VPWR _8241_/D sky130_fd_sc_hd__a22o_1
XFILLER_99_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8160_ _8960_/CLK _8160_/D VGND VGND VPWR VPWR _8160_/Q sky130_fd_sc_hd__dfxtp_1
X_5372_ _8278_/Q _5366_/X _5156_/X _5367_/X VGND VGND VPWR VPWR _8278_/D sky130_fd_sc_hd__a22o_1
X_7111_ _7107_/X _7108_/X _7109_/X _7110_/X _7191_/S0 _7191_/S1 VGND VGND VPWR VPWR
+ _7111_/X sky130_fd_sc_hd__mux4_2
XFILLER_99_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4323_ _8892_/Q _4313_/X _4322_/X _4316_/X VGND VGND VPWR VPWR _8892_/D sky130_fd_sc_hd__a22o_1
X_8091_ _9051_/CLK _8091_/D VGND VGND VPWR VPWR _8091_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_113_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7042_ _6405_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7042_/X sky130_fd_sc_hd__mux2_4
XFILLER_114_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4254_ _8933_/Q _4251_/X _4087_/X _4252_/X VGND VGND VPWR VPWR _8933_/D sky130_fd_sc_hd__a22o_1
XFILLER_101_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4185_ _4199_/A VGND VGND VPWR VPWR _4185_/X sky130_fd_sc_hd__clkbuf_2
X_8993_ _9054_/CLK _8993_/D VGND VGND VPWR VPWR _8993_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_55_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7944_ _8540_/Q _8924_/Q _8860_/Q _8892_/Q _8005_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _7944_/X sky130_fd_sc_hd__mux4_1
XFILLER_55_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_2207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7875_ _8729_/Q _8697_/Q _8665_/Q _8633_/Q _7875_/S0 _7897_/S1 VGND VGND VPWR VPWR
+ _7875_/X sky130_fd_sc_hd__mux4_2
XFILLER_23_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6826_ _6635_/X _7033_/X _6830_/S VGND VGND VPWR VPWR _6826_/X sky130_fd_sc_hd__mux2_1
XPHY_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6757_ _6394_/Y _6249_/B _6777_/S VGND VGND VPWR VPWR _9067_/D sky130_fd_sc_hd__mux2_1
X_5708_ _5715_/A VGND VGND VPWR VPWR _5708_/X sky130_fd_sc_hd__clkbuf_2
X_3969_ _3976_/B _5955_/D VGND VGND VPWR VPWR _3973_/D sky130_fd_sc_hd__nand2_1
X_6688_ _7106_/X _7111_/X _6704_/S VGND VGND VPWR VPWR _6688_/X sky130_fd_sc_hd__mux2_2
X_8427_ _8841_/CLK _8427_/D VGND VGND VPWR VPWR _8427_/Q sky130_fd_sc_hd__dfxtp_1
X_5639_ _5646_/A VGND VGND VPWR VPWR _5639_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_128_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8358_ _8868_/CLK _8358_/D VGND VGND VPWR VPWR _8358_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7309_ _8119_/Q _8087_/Q _8055_/Q _9047_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7309_/X sky130_fd_sc_hd__mux4_1
XFILLER_2_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8289_ _8545_/CLK _8289_/D VGND VGND VPWR VPWR _8289_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_78_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5990_ _6460_/A _5986_/A _7063_/X _5963_/Y VGND VGND VPWR VPWR _5990_/X sky130_fd_sc_hd__o22a_1
XFILLER_18_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4941_ _6809_/X VGND VGND VPWR VPWR _4941_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_18_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4872_ _6805_/X VGND VGND VPWR VPWR _4872_/X sky130_fd_sc_hd__clkbuf_2
X_7660_ _8974_/Q _8398_/Q _8174_/Q _8750_/Q _7700_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7660_/X sky130_fd_sc_hd__mux4_1
XFILLER_33_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6611_ _6865_/X _6584_/X _6991_/X _6606_/X _6610_/Y VGND VGND VPWR VPWR _6611_/Y
+ sky130_fd_sc_hd__o221ai_2
XFILLER_20_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7591_ _7587_/X _7588_/X _7589_/X _7590_/X _7611_/S0 _7611_/S1 VGND VGND VPWR VPWR
+ _7591_/X sky130_fd_sc_hd__mux4_1
XFILLER_118_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6542_ _6825_/X _5999_/X _6826_/X _6004_/Y VGND VGND VPWR VPWR _6542_/X sky130_fd_sc_hd__a22o_1
X_6473_ _6818_/X VGND VGND VPWR VPWR _6473_/Y sky130_fd_sc_hd__inv_2
X_8212_ _9012_/CLK _8212_/D VGND VGND VPWR VPWR _8212_/Q sky130_fd_sc_hd__dfxtp_1
X_5424_ _6802_/X VGND VGND VPWR VPWR _5424_/X sky130_fd_sc_hd__clkbuf_2
X_8143_ _8975_/CLK _8143_/D VGND VGND VPWR VPWR _8143_/Q sky130_fd_sc_hd__dfxtp_1
X_5355_ _5482_/A _5627_/B VGND VGND VPWR VPWR _5394_/A sky130_fd_sc_hd__or2_4
X_8074_ _8708_/CLK _8074_/D VGND VGND VPWR VPWR _8074_/Q sky130_fd_sc_hd__dfxtp_1
X_4306_ _8900_/Q _4302_/X _4091_/X _4303_/X VGND VGND VPWR VPWR _8900_/D sky130_fd_sc_hd__a22o_1
XFILLER_102_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5286_ _8336_/Q _5284_/X _5171_/X _5285_/X VGND VGND VPWR VPWR _8336_/D sky130_fd_sc_hd__a22o_1
XFILLER_101_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4237_ _4251_/A VGND VGND VPWR VPWR _4237_/X sky130_fd_sc_hd__buf_2
X_7025_ _7726_/X _7731_/X _7070_/S VGND VGND VPWR VPWR _7025_/X sky130_fd_sc_hd__mux2_1
X_4168_ _8989_/Q _4162_/X _4006_/X _4165_/X VGND VGND VPWR VPWR _8989_/D sky130_fd_sc_hd__a22o_1
X_4099_ _6779_/X VGND VGND VPWR VPWR _4661_/A sky130_fd_sc_hd__buf_1
X_8976_ _9087_/CLK _8976_/D VGND VGND VPWR VPWR _8976_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_82_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7927_ _8603_/Q _8155_/Q _8507_/Q _8795_/Q _7949_/S0 input9/X VGND VGND VPWR VPWR
+ _7927_/X sky130_fd_sc_hd__mux4_1
XPHY_2026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7858_ _8280_/Q _8248_/Q _8216_/Q _9016_/Q _7894_/S0 _7900_/S1 VGND VGND VPWR VPWR
+ _7858_/X sky130_fd_sc_hd__mux4_1
XPHY_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6809_ _6562_/Y _6558_/Y _6809_/S VGND VGND VPWR VPWR _6809_/X sky130_fd_sc_hd__mux2_4
XPHY_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7789_ _8116_/Q _8084_/Q _8052_/Q _9044_/Q _7885_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7789_/X sky130_fd_sc_hd__mux4_1
XFILLER_139_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5140_ _6807_/X VGND VGND VPWR VPWR _5140_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5071_ _8457_/Q _5067_/X _4916_/X _5068_/X VGND VGND VPWR VPWR _8457_/D sky130_fd_sc_hd__a22o_1
XFILLER_84_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4022_ _6802_/X VGND VGND VPWR VPWR _4607_/A sky130_fd_sc_hd__clkbuf_2
X_8830_ _8958_/CLK _8830_/D VGND VGND VPWR VPWR _8830_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_65_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5973_ _7050_/X _5985_/B VGND VGND VPWR VPWR _5974_/A sky130_fd_sc_hd__nand2_2
XFILLER_52_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8761_ _8794_/CLK _8761_/D VGND VGND VPWR VPWR _8761_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_37_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4924_ _4924_/A VGND VGND VPWR VPWR _4924_/X sky130_fd_sc_hd__buf_2
XFILLER_64_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7712_ _8817_/Q _8337_/Q _8945_/Q _8465_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7712_/X sky130_fd_sc_hd__mux4_1
XFILLER_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8692_ _9051_/CLK _8692_/D VGND VGND VPWR VPWR _8692_/Q sky130_fd_sc_hd__dfxtp_1
X_4855_ _8578_/Q _4849_/X _4659_/X _4850_/X VGND VGND VPWR VPWR _8578_/D sky130_fd_sc_hd__a22o_1
X_7643_ _8429_/Q _8301_/Q _8365_/Q _8557_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7643_/X sky130_fd_sc_hd__mux4_1
XFILLER_138_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7574_ _8522_/Q _8906_/Q _8842_/Q _8874_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7574_/X sky130_fd_sc_hd__mux4_1
X_4786_ _8625_/Q _4780_/X _4623_/X _4781_/X VGND VGND VPWR VPWR _8625_/D sky130_fd_sc_hd__a22o_1
XFILLER_20_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6525_ _6848_/X _5848_/A _6845_/X _6101_/B VGND VGND VPWR VPWR _6525_/X sky130_fd_sc_hd__a22o_1
XFILLER_106_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6456_ _6456_/A _6456_/B VGND VGND VPWR VPWR _6457_/B sky130_fd_sc_hd__or2_1
XFILLER_121_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5407_ _5468_/A VGND VGND VPWR VPWR _5432_/A sky130_fd_sc_hd__buf_4
X_6387_ input4/X VGND VGND VPWR VPWR _6387_/Y sky130_fd_sc_hd__inv_2
X_5338_ _8300_/Q _5332_/X _5180_/X _5333_/X VGND VGND VPWR VPWR _8300_/D sky130_fd_sc_hd__a22o_1
X_8126_ _9055_/CLK _8126_/D VGND VGND VPWR VPWR _8126_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_0_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8057_ _9080_/CLK _8057_/D VGND VGND VPWR VPWR _8057_/Q sky130_fd_sc_hd__dfxtp_1
X_5269_ _8347_/Q _5261_/X _5144_/X _5264_/X VGND VGND VPWR VPWR _8347_/D sky130_fd_sc_hd__a22o_1
X_7008_ _7616_/X _7621_/X _7020_/S VGND VGND VPWR VPWR _7008_/X sky130_fd_sc_hd__mux2_1
XFILLER_29_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8959_ _8959_/CLK _8959_/D VGND VGND VPWR VPWR _8959_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_70_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4640_ _8715_/Q _4637_/X _4638_/X _4639_/X VGND VGND VPWR VPWR _8715_/D sky130_fd_sc_hd__a22o_1
XFILLER_30_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4571_ _8747_/Q _4569_/X _4363_/X _4570_/X VGND VGND VPWR VPWR _8747_/D sky130_fd_sc_hd__a22o_1
X_6310_ _6238_/A _6238_/B _6238_/X _6241_/Y VGND VGND VPWR VPWR _6311_/C sky130_fd_sc_hd__a22o_1
XFILLER_6_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7290_ _8981_/Q _8405_/Q _8181_/Q _8757_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7290_/X sky130_fd_sc_hd__mux4_1
XFILLER_104_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6241_ input4/X _6241_/B VGND VGND VPWR VPWR _6241_/Y sky130_fd_sc_hd__nand2_2
XFILLER_131_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6172_ _9087_/Q _6171_/Y _9087_/Q _6171_/Y VGND VGND VPWR VPWR _6173_/A sky130_fd_sc_hd__o2bb2a_1
X_5123_ _5123_/A VGND VGND VPWR VPWR _5123_/X sky130_fd_sc_hd__buf_2
XFILLER_57_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5054_ _5054_/A VGND VGND VPWR VPWR _5054_/X sky130_fd_sc_hd__clkbuf_2
X_4005_ _6807_/X VGND VGND VPWR VPWR _4595_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_84_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8813_ _8941_/CLK _8813_/D VGND VGND VPWR VPWR _8813_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_53_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8744_ _9000_/CLK _8744_/D VGND VGND VPWR VPWR _8744_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5956_ _5956_/A _6430_/A VGND VGND VPWR VPWR _7068_/S sky130_fd_sc_hd__and2_1
XFILLER_52_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8675_ _8710_/CLK _8675_/D VGND VGND VPWR VPWR _8675_/Q sky130_fd_sc_hd__dfxtp_1
X_5887_ _5886_/A _6513_/B _5886_/Y _5787_/A VGND VGND VPWR VPWR _5887_/X sky130_fd_sc_hd__o22a_1
X_4907_ _8557_/Q _4898_/X _4906_/X _4900_/X VGND VGND VPWR VPWR _8557_/D sky130_fd_sc_hd__a22o_1
XFILLER_52_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7626_ _7622_/X _7623_/X _7624_/X _7625_/X _7711_/S0 _6097_/A VGND VGND VPWR VPWR
+ _7626_/X sky130_fd_sc_hd__mux4_2
X_4838_ _8591_/Q _4835_/X _4629_/X _4836_/X VGND VGND VPWR VPWR _8591_/D sky130_fd_sc_hd__a22o_1
XFILLER_138_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7557_ _8585_/Q _8137_/Q _8489_/Q _8777_/Q _7600_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7557_/X sky130_fd_sc_hd__mux4_1
X_4769_ _8638_/Q _4764_/X _4593_/X _4767_/X VGND VGND VPWR VPWR _8638_/D sky130_fd_sc_hd__a22o_1
X_7488_ _8261_/Q _8229_/Q _8197_/Q _8997_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7488_/X sky130_fd_sc_hd__mux4_1
X_6508_ _6825_/X _5999_/A _6507_/Y _5998_/A VGND VGND VPWR VPWR _6511_/A sky130_fd_sc_hd__a22o_1
XFILLER_136_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6439_ _6467_/A _5963_/Y _6438_/X VGND VGND VPWR VPWR _6439_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_136_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8109_ _9038_/CLK _8109_/D VGND VGND VPWR VPWR _8109_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_48_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XANTENNA_7 _4651_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5810_ _5810_/A VGND VGND VPWR VPWR _5832_/B sky130_fd_sc_hd__inv_2
X_6790_ _6678_/Y _6676_/Y _6809_/S VGND VGND VPWR VPWR _6790_/X sky130_fd_sc_hd__mux2_2
XFILLER_34_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5741_ _5741_/A VGND VGND VPWR VPWR _5741_/X sky130_fd_sc_hd__clkbuf_2
X_8460_ _8940_/CLK _8460_/D VGND VGND VPWR VPWR _8460_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7411_ _7407_/X _7408_/X _7409_/X _7410_/X _8011_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _7411_/X sky130_fd_sc_hd__mux4_1
X_5672_ _8098_/Q _5666_/X _5476_/X _5667_/X VGND VGND VPWR VPWR _8098_/D sky130_fd_sc_hd__a22o_1
XFILLER_30_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8391_ _8999_/CLK _8391_/D VGND VGND VPWR VPWR _8391_/Q sky130_fd_sc_hd__dfxtp_1
X_4623_ _4623_/A VGND VGND VPWR VPWR _4623_/X sky130_fd_sc_hd__buf_2
X_7342_ _8827_/Q _8347_/Q _8955_/Q _8475_/Q _7390_/S0 _6344_/B VGND VGND VPWR VPWR
+ _7342_/X sky130_fd_sc_hd__mux4_1
X_4554_ _8758_/Q _4548_/X _4336_/X _4549_/X VGND VGND VPWR VPWR _8758_/D sky130_fd_sc_hd__a22o_1
X_7273_ _8436_/Q _8308_/Q _8372_/Q _8564_/Q _7359_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7273_/X sky130_fd_sc_hd__mux4_2
X_4485_ _8802_/Q _4479_/X _4384_/X _4480_/X VGND VGND VPWR VPWR _8802_/D sky130_fd_sc_hd__a22o_1
X_9012_ _9012_/CLK _9012_/D VGND VGND VPWR VPWR _9012_/Q sky130_fd_sc_hd__dfxtp_1
X_6224_ _6129_/B _6223_/X _6129_/A VGND VGND VPWR VPWR _6225_/B sky130_fd_sc_hd__o21a_1
XFILLER_112_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6155_ _9078_/Q _6211_/A VGND VGND VPWR VPWR _6156_/A sky130_fd_sc_hd__nand2_1
X_6086_ _7068_/S _6086_/B _6086_/C _6085_/X VGND VGND VPWR VPWR _6086_/X sky130_fd_sc_hd__or4b_4
XFILLER_66_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5106_ _8434_/Q _5101_/X _4894_/X _5102_/X VGND VGND VPWR VPWR _8434_/D sky130_fd_sc_hd__a22o_1
X_5037_ _5053_/A VGND VGND VPWR VPWR _5037_/X sky130_fd_sc_hd__buf_2
XFILLER_81_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6988_ _5952_/Y _3982_/A _7069_/S VGND VGND VPWR VPWR _6988_/X sky130_fd_sc_hd__mux2_4
XFILLER_53_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8727_ _8729_/CLK _8727_/D VGND VGND VPWR VPWR _8727_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_13_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5939_ _6978_/X _5981_/B _6912_/X _5828_/Y VGND VGND VPWR VPWR _5939_/X sky130_fd_sc_hd__a31o_1
XFILLER_139_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8658_ _9051_/CLK _8658_/D VGND VGND VPWR VPWR _8658_/Q sky130_fd_sc_hd__dfxtp_1
X_7609_ _8107_/Q _8075_/Q _8043_/Q _9035_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7609_/X sky130_fd_sc_hd__mux4_1
X_8589_ _8781_/CLK _8589_/D VGND VGND VPWR VPWR _8589_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_135_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_10_0_clk clkbuf_3_5_0_clk/X VGND VGND VPWR VPWR _8944_/CLK sky130_fd_sc_hd__clkbuf_1
XFILLER_135_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput66 _9061_/Q VGND VGND VPWR VPWR imAddr[5] sky130_fd_sc_hd__clkbuf_2
Xoutput55 _9080_/Q VGND VGND VPWR VPWR imAddr[24] sky130_fd_sc_hd__clkbuf_2
XFILLER_1_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput44 _9070_/Q VGND VGND VPWR VPWR imAddr[14] sky130_fd_sc_hd__clkbuf_2
XFILLER_88_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput88 _6733_/X VGND VGND VPWR VPWR regData[25] sky130_fd_sc_hd__clkbuf_2
XFILLER_0_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput99 _6695_/X VGND VGND VPWR VPWR regData[6] sky130_fd_sc_hd__clkbuf_2
XFILLER_1_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xoutput77 _6713_/X VGND VGND VPWR VPWR regData[15] sky130_fd_sc_hd__clkbuf_2
XFILLER_103_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4270_ _8926_/Q _4265_/X _4000_/X _4268_/X VGND VGND VPWR VPWR _8926_/D sky130_fd_sc_hd__a22o_1
XFILLER_95_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7960_ _8989_/Q _8413_/Q _8189_/Q _8765_/Q _8025_/S0 _5772_/B VGND VGND VPWR VPWR
+ _7960_/X sky130_fd_sc_hd__mux4_1
XFILLER_55_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6911_ _6972_/X _6970_/X _6971_/S VGND VGND VPWR VPWR _6911_/X sky130_fd_sc_hd__mux2_1
X_7891_ _7887_/X _7888_/X _7889_/X _7890_/X _5872_/A input11/X VGND VGND VPWR VPWR
+ _7891_/X sky130_fd_sc_hd__mux4_2
X_6842_ _6104_/X _7009_/X _6943_/S VGND VGND VPWR VPWR _6842_/X sky130_fd_sc_hd__mux2_2
XFILLER_50_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3985_ _3985_/A _5955_/D _5955_/B _6291_/A VGND VGND VPWR VPWR _3988_/D sky130_fd_sc_hd__or4_4
X_6773_ _6353_/Y _6331_/Y _6777_/S VGND VGND VPWR VPWR _9083_/D sky130_fd_sc_hd__mux2_1
X_5724_ _5762_/A VGND VGND VPWR VPWR _5741_/A sky130_fd_sc_hd__buf_4
X_8512_ _8928_/CLK _8512_/D VGND VGND VPWR VPWR _8512_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_109_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8443_ _8731_/CLK _8443_/D VGND VGND VPWR VPWR _8443_/Q sky130_fd_sc_hd__dfxtp_1
X_5655_ _8111_/Q _5652_/X _5446_/X _5653_/X VGND VGND VPWR VPWR _8111_/D sky130_fd_sc_hd__a22o_1
XFILLER_117_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4606_ _8729_/Q _4601_/X _4605_/X _4603_/X VGND VGND VPWR VPWR _8729_/D sky130_fd_sc_hd__a22o_1
X_8374_ _8822_/CLK _8374_/D VGND VGND VPWR VPWR _8374_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5586_ _8158_/Q _5581_/X _5410_/X _5584_/X VGND VGND VPWR VPWR _8158_/D sky130_fd_sc_hd__a22o_1
X_7325_ _8729_/Q _8697_/Q _8665_/Q _8633_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7325_/X sky130_fd_sc_hd__mux4_2
XFILLER_132_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4537_ _4537_/A _5531_/A VGND VGND VPWR VPWR _4576_/A sky130_fd_sc_hd__or2_4
XFILLER_117_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7256_ _7252_/X _7253_/X _7254_/X _7255_/X _7286_/S0 input36/X VGND VGND VPWR VPWR
+ _7256_/X sky130_fd_sc_hd__mux4_1
X_4468_ _8815_/Q _4465_/X _4354_/X _4466_/X VGND VGND VPWR VPWR _8815_/D sky130_fd_sc_hd__a22o_1
X_7187_ _8587_/Q _8139_/Q _8491_/Q _8779_/Q _7190_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7187_/X sky130_fd_sc_hd__mux4_2
X_6207_ _6208_/B VGND VGND VPWR VPWR _6207_/Y sky130_fd_sc_hd__inv_2
X_6138_ _9062_/Q VGND VGND VPWR VPWR _6265_/A sky130_fd_sc_hd__inv_2
X_4399_ _8861_/Q _4392_/X _4320_/X _4396_/X VGND VGND VPWR VPWR _8861_/D sky130_fd_sc_hd__a22o_1
XFILLER_86_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater171 _7374_/S1 VGND VGND VPWR VPWR _6344_/B sky130_fd_sc_hd__buf_6
Xrepeater160 _7391_/S0 VGND VGND VPWR VPWR _6343_/C sky130_fd_sc_hd__buf_4
XFILLER_85_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6069_ _6991_/X _5908_/B _6065_/Y _6084_/D _6068_/X VGND VGND VPWR VPWR _6069_/X
+ sky130_fd_sc_hd__o221a_1
Xrepeater193 _7190_/S0 VGND VGND VPWR VPWR _7184_/S0 sky130_fd_sc_hd__buf_8
XFILLER_73_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrepeater182 _7280_/S0 VGND VGND VPWR VPWR _7334_/S0 sky130_fd_sc_hd__buf_8
XFILLER_81_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5440_ _6795_/X VGND VGND VPWR VPWR _5440_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_133_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5371_ _8279_/Q _5366_/X _5154_/X _5367_/X VGND VGND VPWR VPWR _8279_/D sky130_fd_sc_hd__a22o_1
XFILLER_113_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7110_ _8963_/Q _8387_/Q _8163_/Q _8739_/Q _7140_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7110_/X sky130_fd_sc_hd__mux4_1
X_4322_ _4597_/A VGND VGND VPWR VPWR _4322_/X sky130_fd_sc_hd__clkbuf_2
X_8090_ _9078_/CLK _8090_/D VGND VGND VPWR VPWR _8090_/Q sky130_fd_sc_hd__dfxtp_1
X_4253_ _8934_/Q _4251_/X _4083_/X _4252_/X VGND VGND VPWR VPWR _8934_/D sky130_fd_sc_hd__a22o_1
X_7041_ _7836_/X _7841_/X _7059_/S VGND VGND VPWR VPWR _7041_/X sky130_fd_sc_hd__mux2_1
XFILLER_101_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4184_ _8977_/Q _4178_/X _4046_/X _4179_/X VGND VGND VPWR VPWR _8977_/D sky130_fd_sc_hd__a22o_1
X_8992_ _9024_/CLK _8992_/D VGND VGND VPWR VPWR _8992_/Q sky130_fd_sc_hd__dfxtp_1
X_7943_ _8444_/Q _8316_/Q _8380_/Q _8572_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _7943_/X sky130_fd_sc_hd__mux4_1
XFILLER_82_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_2208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7874_ _8537_/Q _8921_/Q _8857_/Q _8889_/Q _7894_/S0 _7897_/S1 VGND VGND VPWR VPWR
+ _7874_/X sky130_fd_sc_hd__mux4_1
XFILLER_35_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6825_ _6629_/X _7036_/X _6830_/S VGND VGND VPWR VPWR _6825_/X sky130_fd_sc_hd__mux2_2
XPHY_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3968_ _6814_/X VGND VGND VPWR VPWR _4261_/A sky130_fd_sc_hd__inv_2
X_6756_ _6392_/Y _6253_/Y _6777_/S VGND VGND VPWR VPWR _9066_/D sky130_fd_sc_hd__mux2_1
XFILLER_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5707_ _5714_/A VGND VGND VPWR VPWR _5707_/X sky130_fd_sc_hd__clkbuf_2
X_6687_ _6686_/X _9058_/Q _6743_/S VGND VGND VPWR VPWR _6687_/X sky130_fd_sc_hd__mux2_4
X_8426_ _8669_/CLK _8426_/D VGND VGND VPWR VPWR _8426_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_12_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5638_ _5645_/A VGND VGND VPWR VPWR _5638_/X sky130_fd_sc_hd__clkbuf_2
X_8357_ _8709_/CLK _8357_/D VGND VGND VPWR VPWR _8357_/Q sky130_fd_sc_hd__dfxtp_1
X_5569_ _8167_/Q _5563_/X _5464_/X _5564_/X VGND VGND VPWR VPWR _8167_/D sky130_fd_sc_hd__a22o_1
XFILLER_88_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7308_ _8279_/Q _8247_/Q _8215_/Q _9015_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7308_/X sky130_fd_sc_hd__mux4_1
XFILLER_105_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8288_ _8928_/CLK _8288_/D VGND VGND VPWR VPWR _8288_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_59_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7239_ _8112_/Q _8080_/Q _8048_/Q _9040_/Q _7339_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7239_/X sky130_fd_sc_hd__mux4_1
XFILLER_86_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4940_ _4957_/A VGND VGND VPWR VPWR _4940_/X sky130_fd_sc_hd__buf_2
XFILLER_92_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4871_ _8572_/Q _4861_/X _4870_/X _4864_/X VGND VGND VPWR VPWR _8572_/D sky130_fd_sc_hd__a22o_1
XFILLER_33_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7590_ _8970_/Q _8394_/Q _8170_/Q _8746_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7590_/X sky130_fd_sc_hd__mux4_1
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6610_ _6612_/A _5996_/X _6585_/X VGND VGND VPWR VPWR _6610_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_60_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6541_ _6541_/A _6541_/B VGND VGND VPWR VPWR _6541_/Y sky130_fd_sc_hd__nor2_1
XFILLER_20_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6472_ _6817_/X _6471_/B _6471_/X VGND VGND VPWR VPWR _6472_/X sky130_fd_sc_hd__a21bo_1
X_8211_ _9012_/CLK _8211_/D VGND VGND VPWR VPWR _8211_/Q sky130_fd_sc_hd__dfxtp_1
X_5423_ _8249_/Q _5418_/X _5422_/X _5420_/X VGND VGND VPWR VPWR _8249_/D sky130_fd_sc_hd__a22o_1
XFILLER_133_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5354_ _8288_/Q _5325_/A _5208_/X _5326_/A VGND VGND VPWR VPWR _8288_/D sky130_fd_sc_hd__a22o_1
X_8142_ _9038_/CLK _8142_/D VGND VGND VPWR VPWR _8142_/Q sky130_fd_sc_hd__dfxtp_1
X_4305_ _8901_/Q _4302_/X _4087_/X _4303_/X VGND VGND VPWR VPWR _8901_/D sky130_fd_sc_hd__a22o_1
X_8073_ _8708_/CLK _8073_/D VGND VGND VPWR VPWR _8073_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_102_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5285_ _5299_/A VGND VGND VPWR VPWR _5285_/X sky130_fd_sc_hd__buf_2
XFILLER_99_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4236_ _8945_/Q _4230_/X _4046_/X _4231_/X VGND VGND VPWR VPWR _8945_/D sky130_fd_sc_hd__a22o_1
X_7024_ _6605_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7024_/X sky130_fd_sc_hd__mux2_2
X_4167_ _8990_/Q _4162_/X _4000_/X _4165_/X VGND VGND VPWR VPWR _8990_/D sky130_fd_sc_hd__a22o_1
XFILLER_74_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4098_ _9026_/Q _4085_/X _4097_/X _4088_/X VGND VGND VPWR VPWR _9026_/D sky130_fd_sc_hd__a22o_1
X_8975_ _8975_/CLK _8975_/D VGND VGND VPWR VPWR _8975_/Q sky130_fd_sc_hd__dfxtp_1
X_7926_ _7922_/X _7923_/X _7924_/X _7925_/X _8006_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _7926_/X sky130_fd_sc_hd__mux4_2
XFILLER_70_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_2016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7857_ _8600_/Q _8152_/Q _8504_/Q _8792_/Q _7894_/S0 _7900_/S1 VGND VGND VPWR VPWR
+ _7857_/X sky130_fd_sc_hd__mux4_1
XPHY_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6808_ _6440_/Y _6569_/Y _6809_/S VGND VGND VPWR VPWR _6808_/X sky130_fd_sc_hd__mux2_2
XPHY_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7788_ _8276_/Q _8244_/Q _8212_/Q _9012_/Q _7885_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7788_/X sky130_fd_sc_hd__mux4_2
XFILLER_23_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6739_ _6738_/X _9084_/Q _6741_/S VGND VGND VPWR VPWR _6739_/X sky130_fd_sc_hd__mux2_1
XPHY_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8409_ _8951_/CLK _8409_/D VGND VGND VPWR VPWR _8409_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_105_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5070_ _8458_/Q _5067_/X _4914_/X _5068_/X VGND VGND VPWR VPWR _8458_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4021_ _9049_/Q _4017_/X _4019_/X _4020_/X VGND VGND VPWR VPWR _9049_/D sky130_fd_sc_hd__a22o_1
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5972_ _7047_/X _5985_/B VGND VGND VPWR VPWR _6482_/A sky130_fd_sc_hd__and2_1
XFILLER_52_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8760_ _9014_/CLK _8760_/D VGND VGND VPWR VPWR _8760_/Q sky130_fd_sc_hd__dfxtp_1
X_4923_ _6784_/X VGND VGND VPWR VPWR _4923_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_80_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7711_ _7707_/X _7708_/X _7709_/X _7710_/X _7711_/S0 input11/X VGND VGND VPWR VPWR
+ _7711_/X sky130_fd_sc_hd__mux4_1
X_8691_ _9019_/CLK _8691_/D VGND VGND VPWR VPWR _8691_/Q sky130_fd_sc_hd__dfxtp_1
X_4854_ _8579_/Q _4849_/X _4657_/X _4850_/X VGND VGND VPWR VPWR _8579_/D sky130_fd_sc_hd__a22o_1
X_7642_ _8813_/Q _8333_/Q _8941_/Q _8461_/Q _7665_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7642_/X sky130_fd_sc_hd__mux4_1
XFILLER_20_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7573_ _8426_/Q _8298_/Q _8362_/Q _8554_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7573_/X sky130_fd_sc_hd__mux4_2
X_4785_ _8626_/Q _4780_/X _4621_/X _4781_/X VGND VGND VPWR VPWR _8626_/D sky130_fd_sc_hd__a22o_1
X_6524_ _6524_/A _6524_/B _6528_/A VGND VGND VPWR VPWR _6524_/Y sky130_fd_sc_hd__nor3_2
XFILLER_20_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6455_ _6455_/A _6455_/B VGND VGND VPWR VPWR _6456_/B sky130_fd_sc_hd__or2_1
X_5406_ _5466_/A VGND VGND VPWR VPWR _5468_/A sky130_fd_sc_hd__inv_2
X_6386_ _6385_/A _6379_/Y _6385_/Y _6379_/A VGND VGND VPWR VPWR _6386_/X sky130_fd_sc_hd__o22a_1
XFILLER_114_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5337_ _8301_/Q _5332_/X _5178_/X _5333_/X VGND VGND VPWR VPWR _8301_/D sky130_fd_sc_hd__a22o_1
X_8125_ _9053_/CLK _8125_/D VGND VGND VPWR VPWR _8125_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_125_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5268_ _8348_/Q _5261_/X _5142_/X _5264_/X VGND VGND VPWR VPWR _8348_/D sky130_fd_sc_hd__a22o_1
XFILLER_102_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8056_ _9075_/CLK _8056_/D VGND VGND VPWR VPWR _8056_/Q sky130_fd_sc_hd__dfxtp_1
X_7007_ _7606_/X _7611_/X _7067_/S VGND VGND VPWR VPWR _7007_/X sky130_fd_sc_hd__mux2_2
X_4219_ _8958_/Q _4214_/X _4000_/X _4217_/X VGND VGND VPWR VPWR _8958_/D sky130_fd_sc_hd__a22o_1
XFILLER_47_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5199_ _8389_/Q _5194_/X _5198_/X _5196_/X VGND VGND VPWR VPWR _8389_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8958_ _8958_/CLK _8958_/D VGND VGND VPWR VPWR _8958_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_71_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7909_ _8122_/Q _8090_/Q _8058_/Q _9050_/Q _7909_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7909_/X sky130_fd_sc_hd__mux4_2
X_8889_ _8951_/CLK _8889_/D VGND VGND VPWR VPWR _8889_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4570_ _4577_/A VGND VGND VPWR VPWR _4570_/X sky130_fd_sc_hd__clkbuf_2
XPHY_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6240_ _6234_/A _6234_/B _6234_/Y VGND VGND VPWR VPWR _6241_/B sky130_fd_sc_hd__a21oi_4
XFILLER_124_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6171_ _9086_/Q _6171_/B VGND VGND VPWR VPWR _6171_/Y sky130_fd_sc_hd__nand2_1
X_5122_ _5122_/A VGND VGND VPWR VPWR _5122_/X sky130_fd_sc_hd__buf_2
XFILLER_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5053_ _5053_/A VGND VGND VPWR VPWR _5053_/X sky130_fd_sc_hd__clkbuf_2
X_4004_ _9054_/Q _3998_/X _4000_/X _4003_/X VGND VGND VPWR VPWR _9054_/D sky130_fd_sc_hd__a22o_1
X_8812_ _8940_/CLK _8812_/D VGND VGND VPWR VPWR _8812_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_53_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8743_ _8999_/CLK _8743_/D VGND VGND VPWR VPWR _8743_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_111_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5955_ _5955_/A _5955_/B _5955_/C _5955_/D VGND VGND VPWR VPWR _6430_/A sky130_fd_sc_hd__or4_4
X_8674_ _8709_/CLK _8674_/D VGND VGND VPWR VPWR _8674_/Q sky130_fd_sc_hd__dfxtp_1
X_4906_ _6791_/X VGND VGND VPWR VPWR _4906_/X sky130_fd_sc_hd__clkbuf_2
X_5886_ _5886_/A VGND VGND VPWR VPWR _5886_/Y sky130_fd_sc_hd__inv_2
X_7625_ _8716_/Q _8684_/Q _8652_/Q _8620_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7625_/X sky130_fd_sc_hd__mux4_2
X_4837_ _8592_/Q _4835_/X _4626_/X _4836_/X VGND VGND VPWR VPWR _8592_/D sky130_fd_sc_hd__a22o_1
XFILLER_119_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7556_ _7552_/X _7553_/X _7554_/X _7555_/X _7996_/S0 _5771_/B VGND VGND VPWR VPWR
+ _7556_/X sky130_fd_sc_hd__mux4_2
X_4768_ _8639_/Q _4764_/X _4668_/X _4767_/X VGND VGND VPWR VPWR _8639_/D sky130_fd_sc_hd__a22o_1
XFILLER_119_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4699_ _4706_/A VGND VGND VPWR VPWR _4699_/X sky130_fd_sc_hd__clkbuf_2
X_7487_ _8581_/Q _8133_/Q _8485_/Q _8773_/Q _7505_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7487_/X sky130_fd_sc_hd__mux4_1
X_6507_ _6825_/X VGND VGND VPWR VPWR _6507_/Y sky130_fd_sc_hd__inv_2
X_6438_ _6621_/A VGND VGND VPWR VPWR _6438_/X sky130_fd_sc_hd__buf_1
XFILLER_115_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8108_ _8236_/CLK _8108_/D VGND VGND VPWR VPWR _8108_/Q sky130_fd_sc_hd__dfxtp_1
X_6369_ _6368_/X _7055_/X VGND VGND VPWR VPWR _6369_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_0_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8039_ _9035_/CLK _8039_/D VGND VGND VPWR VPWR _8039_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_88_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_117_clk clkbuf_4_0_0_clk/X VGND VGND VPWR VPWR _8403_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_31_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_8 _4754_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_99_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_108_clk clkbuf_4_2_0_clk/X VGND VGND VPWR VPWR _8922_/CLK sky130_fd_sc_hd__clkbuf_16
X_5740_ _8054_/Q _5734_/X _4611_/A _5735_/X VGND VGND VPWR VPWR _8054_/D sky130_fd_sc_hd__a22o_1
XFILLER_34_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5671_ _8099_/Q _5666_/X _5474_/X _5667_/X VGND VGND VPWR VPWR _8099_/D sky130_fd_sc_hd__a22o_1
X_7410_ _8961_/Q _8385_/Q _8161_/Q _8737_/Q _7990_/S0 _5872_/B VGND VGND VPWR VPWR
+ _7410_/X sky130_fd_sc_hd__mux4_1
XFILLER_129_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8390_ _8966_/CLK _8390_/D VGND VGND VPWR VPWR _8390_/Q sky130_fd_sc_hd__dfxtp_1
X_4622_ _8722_/Q _4613_/X _4621_/X _4615_/X VGND VGND VPWR VPWR _8722_/D sky130_fd_sc_hd__a22o_1
XFILLER_129_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4553_ _8759_/Q _4548_/X _4334_/X _4549_/X VGND VGND VPWR VPWR _8759_/D sky130_fd_sc_hd__a22o_1
X_7341_ _7337_/X _7338_/X _7339_/X _7340_/X _7341_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7341_/X sky130_fd_sc_hd__mux4_1
X_4484_ _8803_/Q _4479_/X _4382_/X _4480_/X VGND VGND VPWR VPWR _8803_/D sky130_fd_sc_hd__a22o_1
X_7272_ _8820_/Q _8340_/Q _8948_/Q _8468_/Q _7288_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7272_/X sky130_fd_sc_hd__mux4_1
XFILLER_89_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9011_ _9012_/CLK _9011_/D VGND VGND VPWR VPWR _9011_/Q sky130_fd_sc_hd__dfxtp_1
X_6223_ _6223_/A _6234_/A _6234_/B VGND VGND VPWR VPWR _6223_/X sky130_fd_sc_hd__or3_4
XFILLER_97_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6154_ _6154_/A _6154_/B _6154_/C VGND VGND VPWR VPWR _6211_/A sky130_fd_sc_hd__nor3_4
XFILLER_111_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6085_ _6085_/A _6085_/B _6085_/C VGND VGND VPWR VPWR _6085_/X sky130_fd_sc_hd__or3_2
X_5105_ _8435_/Q _5101_/X _4892_/X _5102_/X VGND VGND VPWR VPWR _8435_/D sky130_fd_sc_hd__a22o_1
X_5036_ _5074_/A VGND VGND VPWR VPWR _5053_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_85_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6987_ _7476_/X _7481_/X _7020_/S VGND VGND VPWR VPWR _6987_/X sky130_fd_sc_hd__mux2_4
XFILLER_53_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5938_ _5994_/B VGND VGND VPWR VPWR _5981_/B sky130_fd_sc_hd__buf_2
X_8726_ _8757_/CLK _8726_/D VGND VGND VPWR VPWR _8726_/Q sky130_fd_sc_hd__dfxtp_1
X_5869_ _5882_/A _5890_/A VGND VGND VPWR VPWR _5870_/C sky130_fd_sc_hd__or2_1
X_8657_ _8725_/CLK _8657_/D VGND VGND VPWR VPWR _8657_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7608_ _8267_/Q _8235_/Q _8203_/Q _9003_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7608_/X sky130_fd_sc_hd__mux4_1
X_8588_ _9028_/CLK _8588_/D VGND VGND VPWR VPWR _8588_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7539_ _8104_/Q _8072_/Q _8040_/Q _9032_/Q _7594_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7539_/X sky130_fd_sc_hd__mux4_2
XFILLER_135_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput45 _9071_/Q VGND VGND VPWR VPWR imAddr[15] sky130_fd_sc_hd__clkbuf_2
Xoutput67 _9062_/Q VGND VGND VPWR VPWR imAddr[6] sky130_fd_sc_hd__clkbuf_2
Xoutput56 _9081_/Q VGND VGND VPWR VPWR imAddr[25] sky130_fd_sc_hd__clkbuf_2
XFILLER_49_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput78 _6715_/X VGND VGND VPWR VPWR regData[16] sky130_fd_sc_hd__clkbuf_2
XFILLER_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput89 _6735_/X VGND VGND VPWR VPWR regData[26] sky130_fd_sc_hd__clkbuf_2
XFILLER_1_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6910_ _6969_/X _6967_/X _6971_/S VGND VGND VPWR VPWR _6910_/X sky130_fd_sc_hd__mux2_1
X_7890_ _8985_/Q _8409_/Q _8185_/Q _8761_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7890_/X sky130_fd_sc_hd__mux4_1
X_6841_ _6840_/X _6571_/X _6948_/S VGND VGND VPWR VPWR _6841_/X sky130_fd_sc_hd__mux2_1
XFILLER_35_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8511_ _8959_/CLK _8511_/D VGND VGND VPWR VPWR _8511_/Q sky130_fd_sc_hd__dfxtp_1
X_3984_ input1/X VGND VGND VPWR VPWR _6291_/A sky130_fd_sc_hd__inv_2
XFILLER_50_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6772_ _6351_/Y _6328_/Y _6777_/S VGND VGND VPWR VPWR _9082_/D sky130_fd_sc_hd__mux2_1
XFILLER_22_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5723_ _5723_/A _5723_/B VGND VGND VPWR VPWR _5762_/A sky130_fd_sc_hd__or2_4
X_8442_ _8954_/CLK _8442_/D VGND VGND VPWR VPWR _8442_/Q sky130_fd_sc_hd__dfxtp_1
X_5654_ _8112_/Q _5652_/X _5443_/X _5653_/X VGND VGND VPWR VPWR _8112_/D sky130_fd_sc_hd__a22o_1
XFILLER_31_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8373_ _8821_/CLK _8373_/D VGND VGND VPWR VPWR _8373_/Q sky130_fd_sc_hd__dfxtp_1
X_4605_ _4605_/A VGND VGND VPWR VPWR _4605_/X sky130_fd_sc_hd__clkbuf_2
X_5585_ _8159_/Q _5581_/X _5485_/X _5584_/X VGND VGND VPWR VPWR _8159_/D sky130_fd_sc_hd__a22o_1
X_7324_ _8537_/Q _8921_/Q _8857_/Q _8889_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7324_/X sky130_fd_sc_hd__mux4_2
XFILLER_117_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4536_ _8768_/Q _4507_/A _4388_/X _4508_/A VGND VGND VPWR VPWR _8768_/D sky130_fd_sc_hd__a22o_1
XFILLER_89_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7255_ _8722_/Q _8690_/Q _8658_/Q _8626_/Q _7359_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7255_/X sky130_fd_sc_hd__mux4_1
X_4467_ _8816_/Q _4465_/X _4351_/X _4466_/X VGND VGND VPWR VPWR _8816_/D sky130_fd_sc_hd__a22o_1
X_7186_ _7182_/X _7183_/X _7184_/X _7185_/X _7191_/S0 _7381_/S1 VGND VGND VPWR VPWR
+ _7186_/X sky130_fd_sc_hd__mux4_2
X_4398_ _8862_/Q _4392_/X _4318_/X _4396_/X VGND VGND VPWR VPWR _8862_/D sky130_fd_sc_hd__a22o_1
XFILLER_89_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6206_ _6154_/B _6154_/C _6154_/B _6154_/C VGND VGND VPWR VPWR _6208_/B sky130_fd_sc_hd__a2bb2o_1
XFILLER_131_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6137_ _9063_/Q VGND VGND VPWR VPWR _6139_/A sky130_fd_sc_hd__inv_2
XFILLER_112_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xrepeater161 _7191_/S0 VGND VGND VPWR VPWR _7391_/S0 sky130_fd_sc_hd__clkbuf_8
Xrepeater150 _6714_/S VGND VGND VPWR VPWR _6704_/S sky130_fd_sc_hd__clkbuf_8
X_6068_ _6987_/X _5981_/B _6988_/X _6066_/X VGND VGND VPWR VPWR _6068_/X sky130_fd_sc_hd__a31o_1
XFILLER_73_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater172 _7374_/S1 VGND VGND VPWR VPWR _7185_/S1 sky130_fd_sc_hd__buf_6
Xrepeater194 _7140_/S0 VGND VGND VPWR VPWR _7190_/S0 sky130_fd_sc_hd__buf_8
X_5019_ _5026_/A VGND VGND VPWR VPWR _5019_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_54_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrepeater183 _7280_/S0 VGND VGND VPWR VPWR _7335_/S0 sky130_fd_sc_hd__buf_8
XFILLER_45_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8709_ _8709_/CLK _8709_/D VGND VGND VPWR VPWR _8709_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5370_ _8280_/Q _5366_/X _5152_/X _5367_/X VGND VGND VPWR VPWR _8280_/D sky130_fd_sc_hd__a22o_1
X_4321_ _8893_/Q _4313_/X _4320_/X _4316_/X VGND VGND VPWR VPWR _8893_/D sky130_fd_sc_hd__a22o_1
XFILLER_114_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4252_ _4252_/A VGND VGND VPWR VPWR _4252_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_99_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7040_ _7826_/X _7831_/X _7070_/S VGND VGND VPWR VPWR _7040_/X sky130_fd_sc_hd__mux2_1
XFILLER_67_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4183_ _8978_/Q _4178_/X _4043_/X _4179_/X VGND VGND VPWR VPWR _8978_/D sky130_fd_sc_hd__a22o_1
XFILLER_95_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8991_ _8991_/CLK _8991_/D VGND VGND VPWR VPWR _8991_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_83_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7942_ _8828_/Q _8348_/Q _8956_/Q _8476_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _7942_/X sky130_fd_sc_hd__mux4_1
XFILLER_27_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7873_ _8441_/Q _8313_/Q _8377_/Q _8569_/Q _7894_/S0 _7897_/S1 VGND VGND VPWR VPWR
+ _7873_/X sky130_fd_sc_hd__mux4_1
XFILLER_35_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6824_ _6624_/X _7039_/X _6830_/S VGND VGND VPWR VPWR _6824_/X sky130_fd_sc_hd__mux2_2
XFILLER_23_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6755_ _6400_/X _6305_/Y _6777_/S VGND VGND VPWR VPWR _9065_/D sky130_fd_sc_hd__mux2_1
XFILLER_51_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5706_ _8076_/Q _5700_/X _4635_/A _5701_/X VGND VGND VPWR VPWR _8076_/D sky130_fd_sc_hd__a22o_1
XFILLER_136_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8425_ _8669_/CLK _8425_/D VGND VGND VPWR VPWR _8425_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_30_clk clkbuf_4_7_0_clk/X VGND VGND VPWR VPWR _8669_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_109_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6686_ _7096_/X _7101_/X _6714_/S VGND VGND VPWR VPWR _6686_/X sky130_fd_sc_hd__mux2_1
X_5637_ _8123_/Q _5629_/X _5416_/X _5632_/X VGND VGND VPWR VPWR _8123_/D sky130_fd_sc_hd__a22o_1
XFILLER_12_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8356_ _8708_/CLK _8356_/D VGND VGND VPWR VPWR _8356_/Q sky130_fd_sc_hd__dfxtp_1
X_5568_ _8168_/Q _5563_/X _5462_/X _5564_/X VGND VGND VPWR VPWR _8168_/D sky130_fd_sc_hd__a22o_1
XFILLER_104_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8287_ _9020_/CLK _8287_/D VGND VGND VPWR VPWR _8287_/Q sky130_fd_sc_hd__dfxtp_1
X_4519_ _8781_/Q _4514_/X _4358_/X _4515_/X VGND VGND VPWR VPWR _8781_/D sky130_fd_sc_hd__a22o_1
X_7307_ _8599_/Q _8151_/Q _8503_/Q _8791_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7307_/X sky130_fd_sc_hd__mux4_1
XFILLER_132_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5499_ _8215_/Q _5494_/X _5426_/X _5495_/X VGND VGND VPWR VPWR _8215_/D sky130_fd_sc_hd__a22o_1
X_7238_ _8272_/Q _8240_/Q _8208_/Q _9008_/Q _7339_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7238_/X sky130_fd_sc_hd__mux4_2
XFILLER_132_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7169_ _8105_/Q _8073_/Q _8041_/Q _9033_/Q _7190_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7169_/X sky130_fd_sc_hd__mux4_1
XFILLER_58_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_97_clk clkbuf_4_8_0_clk/X VGND VGND VPWR VPWR _9014_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_85_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_21_clk clkbuf_4_4_0_clk/X VGND VGND VPWR VPWR _9020_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_10_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4870_ _6806_/X VGND VGND VPWR VPWR _4870_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_20_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6540_ _6536_/Y _6495_/A _6538_/X _6539_/X VGND VGND VPWR VPWR _6541_/B sky130_fd_sc_hd__a31oi_2
XFILLER_118_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_12_clk _8032_/CLK VGND VGND VPWR VPWR _8928_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_9_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6471_ _6817_/X _6471_/B VGND VGND VPWR VPWR _6471_/X sky130_fd_sc_hd__or2_1
XFILLER_134_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5422_ _6803_/X VGND VGND VPWR VPWR _5422_/X sky130_fd_sc_hd__buf_2
X_8210_ _9044_/CLK _8210_/D VGND VGND VPWR VPWR _8210_/Q sky130_fd_sc_hd__dfxtp_1
X_5353_ _8289_/Q _5325_/A _5206_/X _5326_/A VGND VGND VPWR VPWR _8289_/D sky130_fd_sc_hd__a22o_1
X_8141_ _9037_/CLK _8141_/D VGND VGND VPWR VPWR _8141_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_114_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4304_ _8902_/Q _4302_/X _4083_/X _4303_/X VGND VGND VPWR VPWR _8902_/D sky130_fd_sc_hd__a22o_1
X_8072_ _9035_/CLK _8072_/D VGND VGND VPWR VPWR _8072_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_99_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5284_ _5298_/A VGND VGND VPWR VPWR _5284_/X sky130_fd_sc_hd__clkbuf_2
Xclkbuf_leaf_79_clk clkbuf_4_11_0_clk/X VGND VGND VPWR VPWR _9037_/CLK sky130_fd_sc_hd__clkbuf_16
X_4235_ _8946_/Q _4230_/X _4043_/X _4231_/X VGND VGND VPWR VPWR _8946_/D sky130_fd_sc_hd__a22o_1
X_7023_ _7716_/X _7721_/X _7059_/S VGND VGND VPWR VPWR _7023_/X sky130_fd_sc_hd__mux2_2
X_4166_ _8991_/Q _4162_/X _4111_/X _4165_/X VGND VGND VPWR VPWR _8991_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4097_ _4659_/A VGND VGND VPWR VPWR _4097_/X sky130_fd_sc_hd__buf_2
XFILLER_82_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8974_ _8975_/CLK _8974_/D VGND VGND VPWR VPWR _8974_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_130_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7925_ _8731_/Q _8699_/Q _8667_/Q _8635_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _7925_/X sky130_fd_sc_hd__mux4_2
XPHY_2017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7856_ _7852_/X _7853_/X _7854_/X _7855_/X _7901_/S0 _8031_/S1 VGND VGND VPWR VPWR
+ _7856_/X sky130_fd_sc_hd__mux4_1
XPHY_2039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6807_ _6567_/Y _6577_/Y _6809_/S VGND VGND VPWR VPWR _6807_/X sky130_fd_sc_hd__mux2_2
XPHY_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4999_ _5006_/A VGND VGND VPWR VPWR _4999_/X sky130_fd_sc_hd__clkbuf_2
X_7787_ _8596_/Q _8148_/Q _8500_/Q _8788_/Q _7885_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7787_/X sky130_fd_sc_hd__mux4_1
X_6738_ _7356_/X _7361_/X _6744_/S VGND VGND VPWR VPWR _6738_/X sky130_fd_sc_hd__mux2_1
XPHY_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6669_ _6524_/B _6668_/X _6524_/B _6668_/X VGND VGND VPWR VPWR _6669_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_136_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8408_ _8952_/CLK _8408_/D VGND VGND VPWR VPWR _8408_/Q sky130_fd_sc_hd__dfxtp_1
X_8339_ _8786_/CLK _8339_/D VGND VGND VPWR VPWR _8339_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_78_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_1_clk clkbuf_4_0_0_clk/X VGND VGND VPWR VPWR _9044_/CLK sky130_fd_sc_hd__clkbuf_16
X_4020_ _4037_/A VGND VGND VPWR VPWR _4020_/X sky130_fd_sc_hd__buf_2
XFILLER_38_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5971_ _7054_/X _5988_/B _7057_/X _5970_/Y VGND VGND VPWR VPWR _5976_/A sky130_fd_sc_hd__a22o_1
XFILLER_18_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4922_ _4922_/A VGND VGND VPWR VPWR _4922_/X sky130_fd_sc_hd__buf_2
X_8690_ _9019_/CLK _8690_/D VGND VGND VPWR VPWR _8690_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_18_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7710_ _8976_/Q _8400_/Q _8176_/Q _8752_/Q _7710_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7710_/X sky130_fd_sc_hd__mux4_1
X_7641_ _7637_/X _7638_/X _7639_/X _7640_/X _7701_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7641_/X sky130_fd_sc_hd__mux4_1
X_4853_ _8580_/Q _4849_/X _4655_/X _4850_/X VGND VGND VPWR VPWR _8580_/D sky130_fd_sc_hd__a22o_1
X_7572_ _8810_/Q _8330_/Q _8938_/Q _8458_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7572_/X sky130_fd_sc_hd__mux4_2
X_4784_ _8627_/Q _4780_/X _4619_/X _4781_/X VGND VGND VPWR VPWR _8627_/D sky130_fd_sc_hd__a22o_1
XFILLER_118_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6523_ _6523_/A _6523_/B VGND VGND VPWR VPWR _6528_/A sky130_fd_sc_hd__or2_2
XFILLER_118_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6454_ _6454_/A _6655_/A _6655_/B VGND VGND VPWR VPWR _6455_/B sky130_fd_sc_hd__or3_1
XFILLER_133_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5405_ _5430_/A VGND VGND VPWR VPWR _5405_/X sky130_fd_sc_hd__buf_2
X_6385_ _6385_/A VGND VGND VPWR VPWR _6385_/Y sky130_fd_sc_hd__inv_2
XFILLER_125_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8124_ _9052_/CLK _8124_/D VGND VGND VPWR VPWR _8124_/Q sky130_fd_sc_hd__dfxtp_1
X_5336_ _8302_/Q _5332_/X _5176_/X _5333_/X VGND VGND VPWR VPWR _8302_/D sky130_fd_sc_hd__a22o_1
X_5267_ _8349_/Q _5261_/X _5140_/X _5264_/X VGND VGND VPWR VPWR _8349_/D sky130_fd_sc_hd__a22o_1
X_8055_ _9080_/CLK _8055_/D VGND VGND VPWR VPWR _8055_/Q sky130_fd_sc_hd__dfxtp_1
X_4218_ _8959_/Q _4214_/X _4111_/X _4217_/X VGND VGND VPWR VPWR _8959_/D sky130_fd_sc_hd__a22o_1
XFILLER_85_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7006_ _6680_/Y _6244_/Y _7069_/S VGND VGND VPWR VPWR _7006_/X sky130_fd_sc_hd__mux2_4
X_5198_ _6783_/X VGND VGND VPWR VPWR _5198_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_56_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4149_ _4149_/A VGND VGND VPWR VPWR _4149_/X sky130_fd_sc_hd__buf_2
XFILLER_56_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8957_ _8959_/CLK _8957_/D VGND VGND VPWR VPWR _8957_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_18_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7908_ _8282_/Q _8250_/Q _8218_/Q _9018_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7908_/X sky130_fd_sc_hd__mux4_1
XFILLER_43_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8888_ _8952_/CLK _8888_/D VGND VGND VPWR VPWR _8888_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7839_ _8119_/Q _8087_/Q _8055_/Q _9047_/Q _7900_/S0 _7900_/S1 VGND VGND VPWR VPWR
+ _7839_/X sky130_fd_sc_hd__mux4_2
XPHY_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6170_ _6170_/A VGND VGND VPWR VPWR _6171_/B sky130_fd_sc_hd__inv_2
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5121_ _8423_/Q _5115_/X _4920_/X _5116_/X VGND VGND VPWR VPWR _8423_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5052_ _8470_/Q _5046_/X _4884_/X _5047_/X VGND VGND VPWR VPWR _8470_/D sky130_fd_sc_hd__a22o_1
XFILLER_93_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4003_ _4037_/A VGND VGND VPWR VPWR _4003_/X sky130_fd_sc_hd__clkbuf_4
XFILLER_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8811_ _8811_/CLK _8811_/D VGND VGND VPWR VPWR _8811_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_93_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8742_ _8934_/CLK _8742_/D VGND VGND VPWR VPWR _8742_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_93_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5954_ _5821_/Y _5822_/Y _7069_/X VGND VGND VPWR VPWR _5954_/X sky130_fd_sc_hd__o21a_1
X_8673_ _8929_/CLK _8673_/D VGND VGND VPWR VPWR _8673_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4905_ _8558_/Q _4898_/X _4904_/X _4900_/X VGND VGND VPWR VPWR _8558_/D sky130_fd_sc_hd__a22o_1
X_5885_ _6918_/S VGND VGND VPWR VPWR _6257_/A sky130_fd_sc_hd__inv_2
X_4836_ _4850_/A VGND VGND VPWR VPWR _4836_/X sky130_fd_sc_hd__clkbuf_2
X_7624_ _8524_/Q _8908_/Q _8844_/Q _8876_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7624_/X sky130_fd_sc_hd__mux4_1
X_7555_ _8713_/Q _8681_/Q _8649_/Q _8617_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7555_/X sky130_fd_sc_hd__mux4_1
XFILLER_21_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4767_ _4781_/A VGND VGND VPWR VPWR _4767_/X sky130_fd_sc_hd__clkbuf_2
X_6506_ _6823_/X _5979_/X _6505_/Y _5978_/A VGND VGND VPWR VPWR _6512_/B sky130_fd_sc_hd__a22o_1
XFILLER_134_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4698_ _4705_/A VGND VGND VPWR VPWR _4698_/X sky130_fd_sc_hd__clkbuf_2
X_7486_ _7482_/X _7483_/X _7484_/X _7485_/X input10/X _6097_/A VGND VGND VPWR VPWR
+ _7486_/X sky130_fd_sc_hd__mux4_2
X_6437_ _6437_/A VGND VGND VPWR VPWR _6467_/A sky130_fd_sc_hd__inv_2
XFILLER_121_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6368_ _6604_/A VGND VGND VPWR VPWR _6368_/X sky130_fd_sc_hd__buf_1
X_8107_ _9035_/CLK _8107_/D VGND VGND VPWR VPWR _8107_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_0_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5319_ _5326_/A VGND VGND VPWR VPWR _5319_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_102_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6299_ _3981_/A _6274_/Y _6298_/X VGND VGND VPWR VPWR _6402_/B sky130_fd_sc_hd__o21a_1
XFILLER_88_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9087_ _9087_/CLK _9087_/D repeater147/X VGND VGND VPWR VPWR _9087_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_102_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8038_ _8966_/CLK _8038_/D VGND VGND VPWR VPWR _8038_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_75_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_9 _4754_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5670_ _8100_/Q _5666_/X _5472_/X _5667_/X VGND VGND VPWR VPWR _8100_/D sky130_fd_sc_hd__a22o_1
XFILLER_89_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4621_ _4621_/A VGND VGND VPWR VPWR _4621_/X sky130_fd_sc_hd__buf_2
X_7340_ _8986_/Q _8410_/Q _8186_/Q _8762_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7340_/X sky130_fd_sc_hd__mux4_1
X_4552_ _8760_/Q _4548_/X _4332_/X _4549_/X VGND VGND VPWR VPWR _8760_/D sky130_fd_sc_hd__a22o_1
X_4483_ _8804_/Q _4479_/X _4380_/X _4480_/X VGND VGND VPWR VPWR _8804_/D sky130_fd_sc_hd__a22o_1
XFILLER_116_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7271_ _7267_/X _7268_/X _7269_/X _7270_/X _7291_/S0 input36/X VGND VGND VPWR VPWR
+ _7271_/X sky130_fd_sc_hd__mux4_1
XFILLER_104_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6222_ _6222_/A _6222_/B _6222_/C VGND VGND VPWR VPWR _6222_/X sky130_fd_sc_hd__or3_1
X_9010_ _9044_/CLK _9010_/D VGND VGND VPWR VPWR _9010_/Q sky130_fd_sc_hd__dfxtp_1
X_6153_ _9075_/Q _6153_/B VGND VGND VPWR VPWR _6154_/C sky130_fd_sc_hd__nand2_2
XFILLER_112_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6084_ _6084_/A _6084_/B _6084_/C _6084_/D VGND VGND VPWR VPWR _6085_/B sky130_fd_sc_hd__or4_4
XFILLER_57_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5104_ _8436_/Q _5101_/X _4890_/X _5102_/X VGND VGND VPWR VPWR _8436_/D sky130_fd_sc_hd__a22o_1
X_5035_ _5035_/A _5259_/A VGND VGND VPWR VPWR _5074_/A sky130_fd_sc_hd__or2_4
XFILLER_122_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6986_ _7466_/X _7471_/X _7022_/S VGND VGND VPWR VPWR _6986_/X sky130_fd_sc_hd__mux2_1
X_8725_ _8725_/CLK _8725_/D VGND VGND VPWR VPWR _8725_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_53_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5937_ _6032_/B VGND VGND VPWR VPWR _5994_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_41_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8656_ _8911_/CLK _8656_/D VGND VGND VPWR VPWR _8656_/Q sky130_fd_sc_hd__dfxtp_1
X_7607_ _8587_/Q _8139_/Q _8491_/Q _8779_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7607_/X sky130_fd_sc_hd__mux4_2
X_5868_ _7006_/X VGND VGND VPWR VPWR _6101_/A sky130_fd_sc_hd__inv_2
X_8587_ _9033_/CLK _8587_/D VGND VGND VPWR VPWR _8587_/Q sky130_fd_sc_hd__dfxtp_1
X_5799_ _5799_/A VGND VGND VPWR VPWR _5800_/A sky130_fd_sc_hd__inv_2
X_4819_ _8604_/Q _4812_/X _4597_/X _4815_/X VGND VGND VPWR VPWR _8604_/D sky130_fd_sc_hd__a22o_1
XFILLER_119_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7538_ _8264_/Q _8232_/Q _8200_/Q _9000_/Q _7594_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7538_/X sky130_fd_sc_hd__mux4_1
XFILLER_135_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7469_ _8100_/Q _8068_/Q _8036_/Q _9028_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7469_/X sky130_fd_sc_hd__mux4_1
XFILLER_135_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput46 _9072_/Q VGND VGND VPWR VPWR imAddr[16] sky130_fd_sc_hd__clkbuf_2
Xoutput57 _9082_/Q VGND VGND VPWR VPWR imAddr[26] sky130_fd_sc_hd__clkbuf_2
Xoutput68 _9063_/Q VGND VGND VPWR VPWR imAddr[7] sky130_fd_sc_hd__clkbuf_2
Xoutput79 _6717_/X VGND VGND VPWR VPWR regData[17] sky130_fd_sc_hd__clkbuf_2
XFILLER_103_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6840_ _6881_/X _6880_/X _6949_/S VGND VGND VPWR VPWR _6840_/X sky130_fd_sc_hd__mux2_1
XFILLER_63_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6771_ _6357_/X _6324_/Y _6777_/S VGND VGND VPWR VPWR _9081_/D sky130_fd_sc_hd__mux2_1
XFILLER_23_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8510_ _8989_/CLK _8510_/D VGND VGND VPWR VPWR _8510_/Q sky130_fd_sc_hd__dfxtp_1
X_3983_ _6284_/A _3988_/C VGND VGND VPWR VPWR _3989_/B sky130_fd_sc_hd__or2_1
X_5722_ _8064_/Q _5693_/A _4663_/A _5694_/A VGND VGND VPWR VPWR _8064_/D sky130_fd_sc_hd__a22o_1
XFILLER_22_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5653_ _5667_/A VGND VGND VPWR VPWR _5653_/X sky130_fd_sc_hd__clkbuf_2
X_8441_ _8729_/CLK _8441_/D VGND VGND VPWR VPWR _8441_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_129_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5584_ _5598_/A VGND VGND VPWR VPWR _5584_/X sky130_fd_sc_hd__clkbuf_2
X_8372_ _8882_/CLK _8372_/D VGND VGND VPWR VPWR _8372_/Q sky130_fd_sc_hd__dfxtp_1
X_4604_ _8730_/Q _4601_/X _4602_/X _4603_/X VGND VGND VPWR VPWR _8730_/D sky130_fd_sc_hd__a22o_1
XFILLER_30_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4535_ _8769_/Q _4507_/A _4386_/X _4508_/A VGND VGND VPWR VPWR _8769_/D sky130_fd_sc_hd__a22o_1
XFILLER_7_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7323_ _8441_/Q _8313_/Q _8377_/Q _8569_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7323_/X sky130_fd_sc_hd__mux4_1
XFILLER_132_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4466_ _4480_/A VGND VGND VPWR VPWR _4466_/X sky130_fd_sc_hd__buf_2
X_7254_ _8530_/Q _8914_/Q _8850_/Q _8882_/Q _7359_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7254_/X sky130_fd_sc_hd__mux4_1
X_7185_ _8715_/Q _8683_/Q _8651_/Q _8619_/Q _7185_/S0 _7185_/S1 VGND VGND VPWR VPWR
+ _7185_/X sky130_fd_sc_hd__mux4_2
XFILLER_132_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4397_ _8863_/Q _4392_/X _4393_/X _4396_/X VGND VGND VPWR VPWR _8863_/D sky130_fd_sc_hd__a22o_1
X_6205_ _6205_/A _6205_/B _6205_/C _6204_/X VGND VGND VPWR VPWR _6205_/X sky130_fd_sc_hd__or4b_4
XFILLER_100_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6136_ _9060_/Q VGND VGND VPWR VPWR _6263_/A sky130_fd_sc_hd__inv_2
XFILLER_133_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrepeater140 _7610_/S0 VGND VGND VPWR VPWR _7505_/S0 sky130_fd_sc_hd__buf_8
Xrepeater162 input35/X VGND VGND VPWR VPWR _7191_/S0 sky130_fd_sc_hd__buf_8
Xrepeater151 _7381_/S1 VGND VGND VPWR VPWR _7191_/S1 sky130_fd_sc_hd__buf_8
XFILLER_100_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6067_ _5914_/A _5799_/A _5920_/A _5802_/A _6066_/X VGND VGND VPWR VPWR _6084_/D
+ sky130_fd_sc_hd__o221ai_4
Xrepeater173 _7190_/S1 VGND VGND VPWR VPWR _7374_/S1 sky130_fd_sc_hd__buf_8
Xrepeater195 _7140_/S0 VGND VGND VPWR VPWR _7179_/S0 sky130_fd_sc_hd__buf_6
X_5018_ _8492_/Q _5012_/X _4908_/X _5013_/X VGND VGND VPWR VPWR _8492_/D sky130_fd_sc_hd__a22o_1
Xrepeater184 _7288_/S0 VGND VGND VPWR VPWR _7280_/S0 sky130_fd_sc_hd__buf_8
XFILLER_39_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6969_ _7003_/X _7006_/X _6974_/S VGND VGND VPWR VPWR _6969_/X sky130_fd_sc_hd__mux2_1
XFILLER_13_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8708_ _8708_/CLK _8708_/D VGND VGND VPWR VPWR _8708_/Q sky130_fd_sc_hd__dfxtp_1
X_8639_ _8734_/CLK _8639_/D VGND VGND VPWR VPWR _8639_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4320_ _4595_/A VGND VGND VPWR VPWR _4320_/X sky130_fd_sc_hd__clkbuf_2
X_4251_ _4251_/A VGND VGND VPWR VPWR _4251_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_113_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4182_ _8979_/Q _4178_/X _4040_/X _4179_/X VGND VGND VPWR VPWR _8979_/D sky130_fd_sc_hd__a22o_1
X_8990_ _9055_/CLK _8990_/D VGND VGND VPWR VPWR _8990_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_28_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7941_ _7937_/X _7938_/X _7939_/X _7940_/X _8031_/S0 _8001_/S1 VGND VGND VPWR VPWR
+ _7941_/X sky130_fd_sc_hd__mux4_1
XFILLER_67_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7872_ _8825_/Q _8345_/Q _8953_/Q _8473_/Q _7894_/S0 _7897_/S1 VGND VGND VPWR VPWR
+ _7872_/X sky130_fd_sc_hd__mux4_1
XFILLER_36_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6823_ _6613_/Y _7042_/X _6830_/S VGND VGND VPWR VPWR _6823_/X sky130_fd_sc_hd__mux2_2
XPHY_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6754_ _6397_/X _6259_/B _6777_/S VGND VGND VPWR VPWR _9064_/D sky130_fd_sc_hd__mux2_1
XFILLER_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5705_ _8077_/Q _5700_/X _4633_/A _5701_/X VGND VGND VPWR VPWR _8077_/D sky130_fd_sc_hd__a22o_1
XFILLER_50_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6685_ _6684_/X _9057_/Q _6733_/S VGND VGND VPWR VPWR _6685_/X sky130_fd_sc_hd__mux2_2
X_8424_ _8669_/CLK _8424_/D VGND VGND VPWR VPWR _8424_/Q sky130_fd_sc_hd__dfxtp_1
X_5636_ _8124_/Q _5629_/X _5414_/X _5632_/X VGND VGND VPWR VPWR _8124_/D sky130_fd_sc_hd__a22o_1
XFILLER_12_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5567_ _8169_/Q _5563_/X _5460_/X _5564_/X VGND VGND VPWR VPWR _8169_/D sky130_fd_sc_hd__a22o_1
X_8355_ _9034_/CLK _8355_/D VGND VGND VPWR VPWR _8355_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8286_ _8989_/CLK _8286_/D VGND VGND VPWR VPWR _8286_/Q sky130_fd_sc_hd__dfxtp_1
X_4518_ _8782_/Q _4514_/X _4356_/X _4515_/X VGND VGND VPWR VPWR _8782_/D sky130_fd_sc_hd__a22o_1
X_7306_ _7302_/X _7303_/X _7304_/X _7305_/X _7341_/S0 _7336_/S1 VGND VGND VPWR VPWR
+ _7306_/X sky130_fd_sc_hd__mux4_2
X_5498_ _8216_/Q _5494_/X _5424_/X _5495_/X VGND VGND VPWR VPWR _8216_/D sky130_fd_sc_hd__a22o_1
XFILLER_104_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4449_ _8828_/Q _4442_/X _4322_/X _4445_/X VGND VGND VPWR VPWR _8828_/D sky130_fd_sc_hd__a22o_1
X_7237_ _8592_/Q _8144_/Q _8496_/Q _8784_/Q _7240_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7237_/X sky130_fd_sc_hd__mux4_1
X_7168_ _8265_/Q _8233_/Q _8201_/Q _9001_/Q _7190_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7168_/X sky130_fd_sc_hd__mux4_1
X_7099_ _8098_/Q _8066_/Q _8034_/Q _9026_/Q _7130_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7099_/X sky130_fd_sc_hd__mux4_1
X_6119_ _6117_/A _6118_/A _6513_/D _6118_/Y VGND VGND VPWR VPWR _6119_/X sky130_fd_sc_hd__o22a_1
XFILLER_19_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6470_ _6816_/X _5963_/Y _6469_/Y _5963_/A VGND VGND VPWR VPWR _6470_/X sky130_fd_sc_hd__a22o_1
X_5421_ _8250_/Q _5418_/X _5419_/X _5420_/X VGND VGND VPWR VPWR _8250_/D sky130_fd_sc_hd__a22o_1
XFILLER_114_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5352_ _8290_/Q _5346_/X _5204_/X _5347_/X VGND VGND VPWR VPWR _8290_/D sky130_fd_sc_hd__a22o_1
XFILLER_99_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8140_ _9038_/CLK _8140_/D VGND VGND VPWR VPWR _8140_/Q sky130_fd_sc_hd__dfxtp_1
X_4303_ _4303_/A VGND VGND VPWR VPWR _4303_/X sky130_fd_sc_hd__clkbuf_2
X_8071_ _9035_/CLK _8071_/D VGND VGND VPWR VPWR _8071_/Q sky130_fd_sc_hd__dfxtp_1
X_7022_ _7706_/X _7711_/X _7022_/S VGND VGND VPWR VPWR _7022_/X sky130_fd_sc_hd__mux2_2
X_5283_ _8337_/Q _5277_/X _5168_/X _5278_/X VGND VGND VPWR VPWR _8337_/D sky130_fd_sc_hd__a22o_1
XFILLER_101_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4234_ _8947_/Q _4230_/X _4040_/X _4231_/X VGND VGND VPWR VPWR _8947_/D sky130_fd_sc_hd__a22o_1
X_4165_ _4179_/A VGND VGND VPWR VPWR _4165_/X sky130_fd_sc_hd__clkbuf_2
X_4096_ _6780_/X VGND VGND VPWR VPWR _4659_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_82_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8973_ _9037_/CLK _8973_/D VGND VGND VPWR VPWR _8973_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_130_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7924_ _8539_/Q _8923_/Q _8859_/Q _8891_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _7924_/X sky130_fd_sc_hd__mux4_1
XFILLER_24_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_2007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7855_ _8728_/Q _8696_/Q _8664_/Q _8632_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7855_/X sky130_fd_sc_hd__mux4_2
XFILLER_36_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6806_ _6574_/Y _6583_/X _6809_/S VGND VGND VPWR VPWR _6806_/X sky130_fd_sc_hd__mux2_4
XFILLER_51_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7786_ _7782_/X _7783_/X _7784_/X _7785_/X _7811_/S0 _8021_/S1 VGND VGND VPWR VPWR
+ _7786_/X sky130_fd_sc_hd__mux4_1
X_4998_ _5005_/A VGND VGND VPWR VPWR _4998_/X sky130_fd_sc_hd__clkbuf_2
X_6737_ _6736_/X _9083_/Q _6741_/S VGND VGND VPWR VPWR _6737_/X sky130_fd_sc_hd__mux2_1
XFILLER_23_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6668_ _6515_/Y _6033_/A _6524_/A _6662_/X VGND VGND VPWR VPWR _6668_/X sky130_fd_sc_hd__o22a_1
XFILLER_136_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5619_ _5619_/A VGND VGND VPWR VPWR _5619_/X sky130_fd_sc_hd__clkbuf_2
X_6599_ _5889_/X _6584_/X _6997_/X _6572_/X _6598_/Y VGND VGND VPWR VPWR _6599_/Y
+ sky130_fd_sc_hd__o221ai_1
X_8407_ _8951_/CLK _8407_/D VGND VGND VPWR VPWR _8407_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_136_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8338_ _8882_/CLK _8338_/D VGND VGND VPWR VPWR _8338_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8269_ _9038_/CLK _8269_/D VGND VGND VPWR VPWR _8269_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_78_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5970_ _5970_/A VGND VGND VPWR VPWR _5970_/Y sky130_fd_sc_hd__inv_2
X_4921_ _8551_/Q _4910_/X _4920_/X _4912_/X VGND VGND VPWR VPWR _8551_/D sky130_fd_sc_hd__a22o_1
XFILLER_92_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4852_ _8581_/Q _4849_/X _4653_/X _4850_/X VGND VGND VPWR VPWR _8581_/D sky130_fd_sc_hd__a22o_1
XFILLER_100_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7640_ _8973_/Q _8397_/Q _8173_/Q _8749_/Q _7659_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7640_/X sky130_fd_sc_hd__mux4_1
XFILLER_60_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7571_ _7567_/X _7568_/X _7569_/X _7570_/X _7611_/S0 _7611_/S1 VGND VGND VPWR VPWR
+ _7571_/X sky130_fd_sc_hd__mux4_1
X_4783_ _8628_/Q _4780_/X _4617_/X _4781_/X VGND VGND VPWR VPWR _8628_/D sky130_fd_sc_hd__a22o_1
XFILLER_20_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6522_ _6842_/X _6677_/B _6521_/Y _6041_/X VGND VGND VPWR VPWR _6523_/B sky130_fd_sc_hd__a22o_1
XFILLER_20_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6453_ _6658_/A _6666_/A _6666_/B VGND VGND VPWR VPWR _6655_/B sky130_fd_sc_hd__or3_4
XFILLER_118_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5404_ _5466_/A VGND VGND VPWR VPWR _5430_/A sky130_fd_sc_hd__buf_4
XFILLER_133_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8123_ _9052_/CLK _8123_/D VGND VGND VPWR VPWR _8123_/Q sky130_fd_sc_hd__dfxtp_1
X_6384_ _6368_/X _7049_/X VGND VGND VPWR VPWR _6384_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_130_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5335_ _8303_/Q _5332_/X _5174_/X _5333_/X VGND VGND VPWR VPWR _8303_/D sky130_fd_sc_hd__a22o_1
XFILLER_125_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5266_ _8350_/Q _5261_/X _5138_/X _5264_/X VGND VGND VPWR VPWR _8350_/D sky130_fd_sc_hd__a22o_1
X_8054_ _9075_/CLK _8054_/D VGND VGND VPWR VPWR _8054_/Q sky130_fd_sc_hd__dfxtp_1
X_7005_ _7596_/X _7601_/X _7071_/S VGND VGND VPWR VPWR _7005_/X sky130_fd_sc_hd__mux2_2
X_4217_ _4231_/A VGND VGND VPWR VPWR _4217_/X sky130_fd_sc_hd__clkbuf_2
X_5197_ _8390_/Q _5194_/X _5195_/X _5196_/X VGND VGND VPWR VPWR _8390_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4148_ _4148_/A VGND VGND VPWR VPWR _4148_/X sky130_fd_sc_hd__buf_2
XFILLER_83_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4079_ _6785_/X VGND VGND VPWR VPWR _4647_/A sky130_fd_sc_hd__clkbuf_2
X_8956_ _8956_/CLK _8956_/D VGND VGND VPWR VPWR _8956_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7907_ _8602_/Q _8154_/Q _8506_/Q _8794_/Q _7907_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7907_/X sky130_fd_sc_hd__mux4_2
XFILLER_24_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8887_ _8951_/CLK _8887_/D VGND VGND VPWR VPWR _8887_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7838_ _8279_/Q _8247_/Q _8215_/Q _9015_/Q _7900_/S0 _7900_/S1 VGND VGND VPWR VPWR
+ _7838_/X sky130_fd_sc_hd__mux4_2
XPHY_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7769_ _8115_/Q _8083_/Q _8051_/Q _9043_/Q _7885_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7769_/X sky130_fd_sc_hd__mux4_2
XFILLER_137_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5120_ _8424_/Q _5115_/X _4918_/X _5116_/X VGND VGND VPWR VPWR _8424_/D sky130_fd_sc_hd__a22o_1
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5051_ _8471_/Q _5046_/X _4882_/X _5047_/X VGND VGND VPWR VPWR _8471_/D sky130_fd_sc_hd__a22o_1
XFILLER_111_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4002_ _4088_/A VGND VGND VPWR VPWR _4037_/A sky130_fd_sc_hd__clkbuf_4
X_8810_ _8907_/CLK _8810_/D VGND VGND VPWR VPWR _8810_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_26_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8741_ _8933_/CLK _8741_/D VGND VGND VPWR VPWR _8741_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_1_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5953_ _5953_/A VGND VGND VPWR VPWR _5953_/Y sky130_fd_sc_hd__inv_2
X_5884_ _5870_/A _5867_/B _5867_/Y VGND VGND VPWR VPWR _5884_/X sky130_fd_sc_hd__a21o_1
X_8672_ _9054_/CLK _8672_/D VGND VGND VPWR VPWR _8672_/Q sky130_fd_sc_hd__dfxtp_1
X_4904_ _6792_/X VGND VGND VPWR VPWR _4904_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_21_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4835_ _4849_/A VGND VGND VPWR VPWR _4835_/X sky130_fd_sc_hd__clkbuf_2
X_7623_ _8428_/Q _8300_/Q _8364_/Q _8556_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7623_/X sky130_fd_sc_hd__mux4_1
X_7554_ _8521_/Q _8905_/Q _8841_/Q _8873_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7554_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4766_ _4802_/A VGND VGND VPWR VPWR _4781_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_119_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6505_ _6823_/X VGND VGND VPWR VPWR _6505_/Y sky130_fd_sc_hd__inv_2
X_7485_ _8709_/Q _8677_/Q _8645_/Q _8613_/Q _7505_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7485_/X sky130_fd_sc_hd__mux4_1
XFILLER_107_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4697_ _8684_/Q _4691_/X _4635_/X _4692_/X VGND VGND VPWR VPWR _8684_/D sky130_fd_sc_hd__a22o_1
XFILLER_20_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6436_ _6620_/A VGND VGND VPWR VPWR _6436_/X sky130_fd_sc_hd__buf_2
X_6367_ _6214_/A _6359_/X _6214_/A _6359_/X VGND VGND VPWR VPWR _6367_/Y sky130_fd_sc_hd__a2bb2oi_1
X_8106_ _8708_/CLK _8106_/D VGND VGND VPWR VPWR _8106_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_121_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5318_ _5325_/A VGND VGND VPWR VPWR _5318_/X sky130_fd_sc_hd__buf_2
XFILLER_0_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6298_ _3981_/A _6274_/Y _5953_/A _6278_/Y VGND VGND VPWR VPWR _6298_/X sky130_fd_sc_hd__a22o_1
XFILLER_88_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9086_ _9086_/CLK _9086_/D repeater147/X VGND VGND VPWR VPWR _9086_/Q sky130_fd_sc_hd__dfrtp_2
X_5249_ _8359_/Q _5243_/X _5192_/X _5244_/X VGND VGND VPWR VPWR _8359_/D sky130_fd_sc_hd__a22o_1
X_8037_ _9029_/CLK _8037_/D VGND VGND VPWR VPWR _8037_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_68_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8939_ _8939_/CLK _8939_/D VGND VGND VPWR VPWR _8939_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4620_ _8723_/Q _4613_/X _4619_/X _4615_/X VGND VGND VPWR VPWR _8723_/D sky130_fd_sc_hd__a22o_1
XPHY_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4551_ _8761_/Q _4548_/X _4330_/X _4549_/X VGND VGND VPWR VPWR _8761_/D sky130_fd_sc_hd__a22o_1
X_4482_ _8805_/Q _4479_/X _4378_/X _4480_/X VGND VGND VPWR VPWR _8805_/D sky130_fd_sc_hd__a22o_1
XFILLER_7_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7270_ _8979_/Q _8403_/Q _8179_/Q _8755_/Q _7280_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7270_/X sky130_fd_sc_hd__mux4_1
X_6221_ _6177_/A _6220_/Y _6201_/A _6220_/A VGND VGND VPWR VPWR _6222_/C sky130_fd_sc_hd__a22o_1
XFILLER_131_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6152_ _6152_/A VGND VGND VPWR VPWR _6153_/B sky130_fd_sc_hd__inv_2
XFILLER_112_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5103_ _8437_/Q _5101_/X _4887_/X _5102_/X VGND VGND VPWR VPWR _8437_/D sky130_fd_sc_hd__a22o_1
X_6083_ _6982_/X _6061_/B _6065_/A _6082_/X VGND VGND VPWR VPWR _6084_/C sky130_fd_sc_hd__a211o_1
XFILLER_111_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5034_ _8480_/Q _5005_/A _4936_/X _5006_/A VGND VGND VPWR VPWR _8480_/D sky130_fd_sc_hd__a22o_1
XFILLER_65_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6985_ _6090_/Y _5953_/Y _7069_/S VGND VGND VPWR VPWR _6985_/X sky130_fd_sc_hd__mux2_4
XFILLER_81_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8724_ _9051_/CLK _8724_/D VGND VGND VPWR VPWR _8724_/Q sky130_fd_sc_hd__dfxtp_1
X_5936_ _6037_/B VGND VGND VPWR VPWR _6032_/B sky130_fd_sc_hd__buf_2
XFILLER_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8655_ _8911_/CLK _8655_/D VGND VGND VPWR VPWR _8655_/Q sky130_fd_sc_hd__dfxtp_1
X_7606_ _7602_/X _7603_/X _7604_/X _7605_/X _7611_/S0 _7611_/S1 VGND VGND VPWR VPWR
+ _7606_/X sky130_fd_sc_hd__mux4_2
X_5867_ _5870_/A _5867_/B VGND VGND VPWR VPWR _5867_/Y sky130_fd_sc_hd__nor2_1
X_8586_ _8586_/CLK _8586_/D VGND VGND VPWR VPWR _8586_/Q sky130_fd_sc_hd__dfxtp_1
X_4818_ _8605_/Q _4812_/X _4595_/X _4815_/X VGND VGND VPWR VPWR _8605_/D sky130_fd_sc_hd__a22o_1
X_5798_ _6987_/X _6043_/B VGND VGND VPWR VPWR _5799_/A sky130_fd_sc_hd__nand2_2
XFILLER_135_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4749_ _8650_/Q _4746_/X _4641_/X _4747_/X VGND VGND VPWR VPWR _8650_/D sky130_fd_sc_hd__a22o_1
X_7537_ _8584_/Q _8136_/Q _8488_/Q _8776_/Q _7594_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7537_/X sky130_fd_sc_hd__mux4_1
XFILLER_31_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7468_ _8260_/Q _8228_/Q _8196_/Q _8996_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7468_/X sky130_fd_sc_hd__mux4_1
XFILLER_135_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6419_ _6792_/X _6791_/X _6790_/X _6789_/X VGND VGND VPWR VPWR _6422_/B sky130_fd_sc_hd__or4_4
Xoutput58 _9083_/Q VGND VGND VPWR VPWR imAddr[27] sky130_fd_sc_hd__clkbuf_2
X_7399_ _8097_/Q _8065_/Q _8033_/Q _9025_/Q _5771_/A _5772_/B VGND VGND VPWR VPWR
+ _7399_/X sky130_fd_sc_hd__mux4_1
Xoutput47 _9073_/Q VGND VGND VPWR VPWR imAddr[17] sky130_fd_sc_hd__clkbuf_2
Xoutput69 _9064_/Q VGND VGND VPWR VPWR imAddr[8] sky130_fd_sc_hd__clkbuf_2
XFILLER_115_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9069_ _9069_/CLK _9069_/D repeater146/X VGND VGND VPWR VPWR _9069_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_102_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3982_ _3982_/A _5953_/A _3982_/C VGND VGND VPWR VPWR _3988_/C sky130_fd_sc_hd__or3_1
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6770_ _6355_/Y _6320_/Y _6777_/S VGND VGND VPWR VPWR _9080_/D sky130_fd_sc_hd__mux2_1
X_5721_ _8065_/Q _5693_/A _4661_/A _5694_/A VGND VGND VPWR VPWR _8065_/D sky130_fd_sc_hd__a22o_1
XFILLER_16_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5652_ _5666_/A VGND VGND VPWR VPWR _5652_/X sky130_fd_sc_hd__clkbuf_2
X_8440_ _8954_/CLK _8440_/D VGND VGND VPWR VPWR _8440_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_30_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5583_ _5619_/A VGND VGND VPWR VPWR _5598_/A sky130_fd_sc_hd__buf_4
X_8371_ _8786_/CLK _8371_/D VGND VGND VPWR VPWR _8371_/Q sky130_fd_sc_hd__dfxtp_1
X_4603_ _4615_/A VGND VGND VPWR VPWR _4603_/X sky130_fd_sc_hd__clkbuf_2
X_4534_ _8770_/Q _4528_/X _4384_/X _4529_/X VGND VGND VPWR VPWR _8770_/D sky130_fd_sc_hd__a22o_1
XFILLER_7_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7322_ _8825_/Q _8345_/Q _8953_/Q _8473_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7322_/X sky130_fd_sc_hd__mux4_1
XFILLER_116_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4465_ _4479_/A VGND VGND VPWR VPWR _4465_/X sky130_fd_sc_hd__buf_2
X_7253_ _8434_/Q _8306_/Q _8370_/Q _8562_/Q _7359_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7253_/X sky130_fd_sc_hd__mux4_1
X_7184_ _8523_/Q _8907_/Q _8843_/Q _8875_/Q _7184_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7184_/X sky130_fd_sc_hd__mux4_1
X_4396_ _4410_/A VGND VGND VPWR VPWR _4396_/X sky130_fd_sc_hd__clkbuf_2
X_6204_ _6201_/X _6203_/A _6178_/A _6203_/Y VGND VGND VPWR VPWR _6204_/X sky130_fd_sc_hd__o22a_1
X_6135_ _9061_/Q VGND VGND VPWR VPWR _6264_/A sky130_fd_sc_hd__inv_2
XFILLER_133_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6066_ _6988_/X _5914_/B _6985_/X _5920_/B VGND VGND VPWR VPWR _6066_/X sky130_fd_sc_hd__o22a_1
Xrepeater141 _7608_/S0 VGND VGND VPWR VPWR _7610_/S0 sky130_fd_sc_hd__buf_8
Xrepeater152 _7381_/S1 VGND VGND VPWR VPWR _6343_/B sky130_fd_sc_hd__buf_4
XFILLER_73_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5017_ _8493_/Q _5012_/X _4906_/X _5013_/X VGND VGND VPWR VPWR _8493_/D sky130_fd_sc_hd__a22o_1
Xrepeater130 _7885_/S0 VGND VGND VPWR VPWR _7905_/S0 sky130_fd_sc_hd__buf_8
Xrepeater174 _7180_/S1 VGND VGND VPWR VPWR _7190_/S1 sky130_fd_sc_hd__buf_6
Xrepeater185 _7359_/S0 VGND VGND VPWR VPWR _7288_/S0 sky130_fd_sc_hd__buf_8
Xrepeater163 _7240_/S1 VGND VGND VPWR VPWR _7340_/S1 sky130_fd_sc_hd__buf_8
Xrepeater196 _7229_/S0 VGND VGND VPWR VPWR _7140_/S0 sky130_fd_sc_hd__buf_8
XFILLER_26_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8707_ _8710_/CLK _8707_/D VGND VGND VPWR VPWR _8707_/Q sky130_fd_sc_hd__dfxtp_1
X_6968_ _6970_/X _6969_/X _6971_/S VGND VGND VPWR VPWR _6968_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5919_ _6985_/X VGND VGND VPWR VPWR _5920_/A sky130_fd_sc_hd__inv_2
X_6899_ _6898_/X _6911_/X _6964_/S VGND VGND VPWR VPWR _6899_/X sky130_fd_sc_hd__mux2_1
XFILLER_139_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8638_ _8734_/CLK _8638_/D VGND VGND VPWR VPWR _8638_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8569_ _8665_/CLK _8569_/D VGND VGND VPWR VPWR _8569_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_122_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_83_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4250_ _8935_/Q _4244_/X _4080_/X _4245_/X VGND VGND VPWR VPWR _8935_/D sky130_fd_sc_hd__a22o_1
X_4181_ _8980_/Q _4178_/X _4036_/X _4179_/X VGND VGND VPWR VPWR _8980_/D sky130_fd_sc_hd__a22o_1
XFILLER_79_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7940_ _8988_/Q _8412_/Q _8188_/Q _8764_/Q _8000_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7940_/X sky130_fd_sc_hd__mux4_1
XFILLER_82_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7871_ _7867_/X _7868_/X _7869_/X _7870_/X _5872_/A input11/X VGND VGND VPWR VPWR
+ _7871_/X sky130_fd_sc_hd__mux4_2
X_6822_ _6609_/X _7045_/X _6830_/S VGND VGND VPWR VPWR _6822_/X sky130_fd_sc_hd__mux2_2
XFILLER_90_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6753_ _6404_/X _6268_/B _6777_/S VGND VGND VPWR VPWR _9063_/D sky130_fd_sc_hd__mux2_1
X_6684_ _7086_/X _7091_/X _6744_/S VGND VGND VPWR VPWR _6684_/X sky130_fd_sc_hd__mux2_2
X_5704_ _8078_/Q _5700_/X _4631_/A _5701_/X VGND VGND VPWR VPWR _8078_/D sky130_fd_sc_hd__a22o_1
XFILLER_109_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8423_ _8456_/CLK _8423_/D VGND VGND VPWR VPWR _8423_/Q sky130_fd_sc_hd__dfxtp_1
X_5635_ _8125_/Q _5629_/X _5412_/X _5632_/X VGND VGND VPWR VPWR _8125_/D sky130_fd_sc_hd__a22o_1
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_128_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5566_ _8170_/Q _5563_/X _5458_/X _5564_/X VGND VGND VPWR VPWR _8170_/D sky130_fd_sc_hd__a22o_1
X_8354_ _8934_/CLK _8354_/D VGND VGND VPWR VPWR _8354_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_105_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8285_ _8989_/CLK _8285_/D VGND VGND VPWR VPWR _8285_/Q sky130_fd_sc_hd__dfxtp_1
X_7305_ _8727_/Q _8695_/Q _8663_/Q _8631_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7305_/X sky130_fd_sc_hd__mux4_2
X_5497_ _8217_/Q _5494_/X _5422_/X _5495_/X VGND VGND VPWR VPWR _8217_/D sky130_fd_sc_hd__a22o_1
X_4517_ _8783_/Q _4514_/X _4354_/X _4515_/X VGND VGND VPWR VPWR _8783_/D sky130_fd_sc_hd__a22o_1
X_4448_ _8829_/Q _4442_/X _4320_/X _4445_/X VGND VGND VPWR VPWR _8829_/D sky130_fd_sc_hd__a22o_1
X_7236_ _7232_/X _7233_/X _7234_/X _7235_/X _7241_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7236_/X sky130_fd_sc_hd__mux4_1
XFILLER_104_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7167_ _8585_/Q _8137_/Q _8489_/Q _8777_/Q _7190_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7167_/X sky130_fd_sc_hd__mux4_1
X_4379_ _8869_/Q _4374_/X _4378_/X _4376_/X VGND VGND VPWR VPWR _8869_/D sky130_fd_sc_hd__a22o_1
XFILLER_58_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7098_ _8258_/Q _8226_/Q _8194_/Q _8994_/Q _7130_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7098_/X sky130_fd_sc_hd__mux4_1
X_6118_ _6118_/A VGND VGND VPWR VPWR _6118_/Y sky130_fd_sc_hd__inv_2
XFILLER_100_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6049_ _6101_/A _6044_/A _6677_/A _6041_/X _6048_/Y VGND VGND VPWR VPWR _6049_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_100_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5420_ _5432_/A VGND VGND VPWR VPWR _5420_/X sky130_fd_sc_hd__clkbuf_2
X_5351_ _8291_/Q _5346_/X _5202_/X _5347_/X VGND VGND VPWR VPWR _8291_/D sky130_fd_sc_hd__a22o_1
XFILLER_126_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4302_ _4302_/A VGND VGND VPWR VPWR _4302_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_99_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8070_ _8966_/CLK _8070_/D VGND VGND VPWR VPWR _8070_/Q sky130_fd_sc_hd__dfxtp_1
X_5282_ _8338_/Q _5277_/X _5166_/X _5278_/X VGND VGND VPWR VPWR _8338_/D sky130_fd_sc_hd__a22o_1
XFILLER_102_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4233_ _8948_/Q _4230_/X _4036_/X _4231_/X VGND VGND VPWR VPWR _8948_/D sky130_fd_sc_hd__a22o_1
X_7021_ _6619_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7021_/X sky130_fd_sc_hd__mux2_2
X_4164_ _4200_/A VGND VGND VPWR VPWR _4179_/A sky130_fd_sc_hd__buf_4
XFILLER_110_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4095_ _9027_/Q _4085_/X _4094_/X _4088_/X VGND VGND VPWR VPWR _9027_/D sky130_fd_sc_hd__a22o_1
XFILLER_83_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8972_ _9004_/CLK _8972_/D VGND VGND VPWR VPWR _8972_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_68_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7923_ _8443_/Q _8315_/Q _8379_/Q _8571_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _7923_/X sky130_fd_sc_hd__mux4_2
XPHY_2008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7854_ _8536_/Q _8920_/Q _8856_/Q _8888_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7854_/X sky130_fd_sc_hd__mux4_1
XPHY_2019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6805_ _6580_/Y _6591_/Y _6809_/S VGND VGND VPWR VPWR _6805_/X sky130_fd_sc_hd__mux2_4
X_7785_ _8724_/Q _8692_/Q _8660_/Q _8628_/Q _7949_/S0 input9/X VGND VGND VPWR VPWR
+ _7785_/X sky130_fd_sc_hd__mux4_2
XPHY_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4997_ _8507_/Q _4989_/X _4872_/X _4992_/X VGND VGND VPWR VPWR _8507_/D sky130_fd_sc_hd__a22o_1
X_6736_ _7346_/X _7351_/X _6744_/S VGND VGND VPWR VPWR _6736_/X sky130_fd_sc_hd__mux2_1
XPHY_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6667_ _7018_/X _6666_/Y _6655_/B VGND VGND VPWR VPWR _6667_/Y sky130_fd_sc_hd__o21ai_1
X_5618_ _5618_/A VGND VGND VPWR VPWR _5618_/X sky130_fd_sc_hd__clkbuf_2
X_8406_ _8950_/CLK _8406_/D VGND VGND VPWR VPWR _8406_/Q sky130_fd_sc_hd__dfxtp_1
X_6598_ _6460_/A _5986_/Y _6585_/X VGND VGND VPWR VPWR _6598_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_3_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5549_ _5549_/A VGND VGND VPWR VPWR _5549_/X sky130_fd_sc_hd__buf_2
X_8337_ _8945_/CLK _8337_/D VGND VGND VPWR VPWR _8337_/Q sky130_fd_sc_hd__dfxtp_1
X_8268_ _9062_/CLK _8268_/D VGND VGND VPWR VPWR _8268_/Q sky130_fd_sc_hd__dfxtp_1
X_8199_ _9061_/CLK _8199_/D VGND VGND VPWR VPWR _8199_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_78_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7219_ _8110_/Q _8078_/Q _8046_/Q _9038_/Q _7229_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7219_/X sky130_fd_sc_hd__mux4_1
XFILLER_48_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4920_ _6785_/X VGND VGND VPWR VPWR _4920_/X sky130_fd_sc_hd__clkbuf_2
X_4851_ _8582_/Q _4849_/X _4650_/X _4850_/X VGND VGND VPWR VPWR _8582_/D sky130_fd_sc_hd__a22o_1
XFILLER_33_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7570_ _8969_/Q _8393_/Q _8169_/Q _8745_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7570_/X sky130_fd_sc_hd__mux4_1
X_4782_ _8629_/Q _4780_/X _4614_/X _4781_/X VGND VGND VPWR VPWR _8629_/D sky130_fd_sc_hd__a22o_1
XFILLER_60_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6521_ _6842_/X VGND VGND VPWR VPWR _6521_/Y sky130_fd_sc_hd__inv_2
X_6452_ _6452_/A _6673_/A _6452_/C VGND VGND VPWR VPWR _6666_/B sky130_fd_sc_hd__or3_4
XFILLER_133_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5403_ _5482_/A _5675_/B VGND VGND VPWR VPWR _5466_/A sky130_fd_sc_hd__or2_4
XFILLER_133_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8122_ _9048_/CLK _8122_/D VGND VGND VPWR VPWR _8122_/Q sky130_fd_sc_hd__dfxtp_1
X_6383_ _6311_/B _6380_/X _6311_/B _6380_/X VGND VGND VPWR VPWR _6383_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_130_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5334_ _8304_/Q _5332_/X _5171_/X _5333_/X VGND VGND VPWR VPWR _8304_/D sky130_fd_sc_hd__a22o_1
XFILLER_125_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5265_ _8351_/Q _5261_/X _5213_/X _5264_/X VGND VGND VPWR VPWR _8351_/D sky130_fd_sc_hd__a22o_1
XFILLER_88_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8053_ _8981_/CLK _8053_/D VGND VGND VPWR VPWR _8053_/Q sky130_fd_sc_hd__dfxtp_1
X_7004_ _7586_/X _7591_/X _7067_/S VGND VGND VPWR VPWR _7004_/X sky130_fd_sc_hd__mux2_2
X_5196_ _5196_/A VGND VGND VPWR VPWR _5196_/X sky130_fd_sc_hd__buf_2
X_4216_ _4252_/A VGND VGND VPWR VPWR _4231_/A sky130_fd_sc_hd__clkbuf_4
X_4147_ _8999_/Q _4141_/X _4080_/X _4142_/X VGND VGND VPWR VPWR _8999_/D sky130_fd_sc_hd__a22o_1
XFILLER_96_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4078_ _9032_/Q _4068_/X _4077_/X _4071_/X VGND VGND VPWR VPWR _9032_/D sky130_fd_sc_hd__a22o_1
X_8955_ _8956_/CLK _8955_/D VGND VGND VPWR VPWR _8955_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7906_ _7902_/X _7903_/X _7904_/X _7905_/X _5872_/A _5873_/B VGND VGND VPWR VPWR
+ _7906_/X sky130_fd_sc_hd__mux4_1
X_8886_ _8950_/CLK _8886_/D VGND VGND VPWR VPWR _8886_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_43_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7837_ _8599_/Q _8151_/Q _8503_/Q _8791_/Q _7900_/S0 _7900_/S1 VGND VGND VPWR VPWR
+ _7837_/X sky130_fd_sc_hd__mux4_1
XPHY_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7768_ _8275_/Q _8243_/Q _8211_/Q _9011_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7768_/X sky130_fd_sc_hd__mux4_2
XFILLER_137_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6719_ _6718_/X _9074_/Q _6745_/S VGND VGND VPWR VPWR _6719_/X sky130_fd_sc_hd__mux2_1
XPHY_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7699_ _8112_/Q _8080_/Q _8048_/Q _9040_/Q _7700_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7699_/X sky130_fd_sc_hd__mux4_1
XFILLER_20_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5050_ _8472_/Q _5046_/X _4880_/X _5047_/X VGND VGND VPWR VPWR _8472_/D sky130_fd_sc_hd__a22o_1
XFILLER_111_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4001_ _4085_/A VGND VGND VPWR VPWR _4088_/A sky130_fd_sc_hd__inv_2
XFILLER_78_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8740_ _8966_/CLK _8740_/D VGND VGND VPWR VPWR _8740_/Q sky130_fd_sc_hd__dfxtp_1
X_5952_ _5951_/X _6989_/X VGND VGND VPWR VPWR _5952_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_80_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4903_ _8559_/Q _4898_/X _4902_/X _4900_/X VGND VGND VPWR VPWR _8559_/D sky130_fd_sc_hd__a22o_1
X_8671_ _8734_/CLK _8671_/D VGND VGND VPWR VPWR _8671_/Q sky130_fd_sc_hd__dfxtp_1
X_5883_ _6850_/X _5844_/X _5846_/X _5882_/Y VGND VGND VPWR VPWR _5883_/Y sky130_fd_sc_hd__o22ai_1
X_7622_ _8812_/Q _8332_/Q _8940_/Q _8460_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7622_/X sky130_fd_sc_hd__mux4_1
XFILLER_61_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4834_ _8593_/Q _4828_/X _4623_/X _4829_/X VGND VGND VPWR VPWR _8593_/D sky130_fd_sc_hd__a22o_1
X_4765_ _4801_/A VGND VGND VPWR VPWR _4802_/A sky130_fd_sc_hd__inv_4
X_7553_ _8425_/Q _8297_/Q _8361_/Q _8553_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7553_/X sky130_fd_sc_hd__mux4_1
X_6504_ _6824_/X _5996_/X _6503_/Y _5995_/A VGND VGND VPWR VPWR _6512_/A sky130_fd_sc_hd__a22o_1
X_7484_ _8517_/Q _8901_/Q _8837_/Q _8869_/Q _7505_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7484_/X sky130_fd_sc_hd__mux4_2
X_4696_ _8685_/Q _4691_/X _4633_/X _4692_/X VGND VGND VPWR VPWR _8685_/D sky130_fd_sc_hd__a22o_1
XFILLER_134_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6435_ _6948_/S _6435_/B VGND VGND VPWR VPWR _6620_/A sky130_fd_sc_hd__or2_4
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6366_ _6222_/B _6360_/X _6222_/B _6360_/X VGND VGND VPWR VPWR _6366_/Y sky130_fd_sc_hd__a2bb2oi_1
X_8105_ _8586_/CLK _8105_/D VGND VGND VPWR VPWR _8105_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_114_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5317_ _8315_/Q _5309_/X _5144_/X _5312_/X VGND VGND VPWR VPWR _8315_/D sky130_fd_sc_hd__a22o_1
XFILLER_88_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9085_ _9086_/CLK _9085_/D repeater147/X VGND VGND VPWR VPWR _9085_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_114_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8036_ _8966_/CLK _8036_/D VGND VGND VPWR VPWR _8036_/Q sky130_fd_sc_hd__dfxtp_1
X_6297_ _6297_/A _6297_/B _6297_/C VGND VGND VPWR VPWR _6402_/A sky130_fd_sc_hd__nor3_4
X_5248_ _8360_/Q _5243_/X _5190_/X _5244_/X VGND VGND VPWR VPWR _8360_/D sky130_fd_sc_hd__a22o_1
XFILLER_102_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5179_ _8397_/Q _5170_/X _5178_/X _5172_/X VGND VGND VPWR VPWR _8397_/D sky130_fd_sc_hd__a22o_1
XFILLER_84_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8938_ _8938_/CLK _8938_/D VGND VGND VPWR VPWR _8938_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_43_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8869_ _8869_/CLK _8869_/D VGND VGND VPWR VPWR _8869_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_101_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4550_ _8762_/Q _4548_/X _4327_/X _4549_/X VGND VGND VPWR VPWR _8762_/D sky130_fd_sc_hd__a22o_1
X_4481_ _8806_/Q _4479_/X _4375_/X _4480_/X VGND VGND VPWR VPWR _8806_/D sky130_fd_sc_hd__a22o_1
XFILLER_7_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6220_ _6220_/A VGND VGND VPWR VPWR _6220_/Y sky130_fd_sc_hd__inv_2
X_6151_ _9074_/Q _6151_/B VGND VGND VPWR VPWR _6152_/A sky130_fd_sc_hd__nand2_1
XFILLER_97_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5102_ _5102_/A VGND VGND VPWR VPWR _5102_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6082_ _5943_/A _5944_/B _5944_/A _5815_/A VGND VGND VPWR VPWR _6082_/X sky130_fd_sc_hd__a22o_1
XFILLER_97_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5033_ _8481_/Q _5005_/A _4934_/X _5006_/A VGND VGND VPWR VPWR _8481_/D sky130_fd_sc_hd__a22o_1
XFILLER_57_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6984_ _7456_/X _7461_/X _7020_/S VGND VGND VPWR VPWR _6984_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5935_ _6043_/B VGND VGND VPWR VPWR _6037_/B sky130_fd_sc_hd__clkbuf_4
XFILLER_81_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8723_ _9019_/CLK _8723_/D VGND VGND VPWR VPWR _8723_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5866_ _5882_/A _5866_/B VGND VGND VPWR VPWR _5867_/B sky130_fd_sc_hd__or2_1
X_8654_ _8877_/CLK _8654_/D VGND VGND VPWR VPWR _8654_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_33_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7605_ _8715_/Q _8683_/Q _8651_/Q _8619_/Q input8/X _7985_/S1 VGND VGND VPWR VPWR
+ _7605_/X sky130_fd_sc_hd__mux4_2
Xclkbuf_leaf_60_clk clkbuf_4_15_0_clk/X VGND VGND VPWR VPWR _8934_/CLK sky130_fd_sc_hd__clkbuf_16
X_4817_ _8606_/Q _4812_/X _4593_/X _4815_/X VGND VGND VPWR VPWR _8606_/D sky130_fd_sc_hd__a22o_1
XFILLER_21_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8585_ _8586_/CLK _8585_/D VGND VGND VPWR VPWR _8585_/Q sky130_fd_sc_hd__dfxtp_1
X_5797_ _5797_/A _5797_/B VGND VGND VPWR VPWR _5832_/C sky130_fd_sc_hd__or2_1
XFILLER_31_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4748_ _8651_/Q _4746_/X _4638_/X _4747_/X VGND VGND VPWR VPWR _8651_/D sky130_fd_sc_hd__a22o_1
X_7536_ _7532_/X _7533_/X _7534_/X _7535_/X _7996_/S0 _5771_/B VGND VGND VPWR VPWR
+ _7536_/X sky130_fd_sc_hd__mux4_2
XFILLER_31_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7467_ _8580_/Q _8132_/Q _8484_/Q _8772_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7467_/X sky130_fd_sc_hd__mux4_2
X_4679_ _8698_/Q _4677_/X _4602_/X _4678_/X VGND VGND VPWR VPWR _8698_/D sky130_fd_sc_hd__a22o_1
X_6418_ _6788_/X _6787_/X _6786_/X _6785_/X VGND VGND VPWR VPWR _6422_/A sky130_fd_sc_hd__or4_1
Xoutput48 _9074_/Q VGND VGND VPWR VPWR imAddr[18] sky130_fd_sc_hd__clkbuf_2
XFILLER_122_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7398_ _8257_/Q _8225_/Q _8193_/Q _8993_/Q _5771_/A _5772_/B VGND VGND VPWR VPWR
+ _7398_/X sky130_fd_sc_hd__mux4_2
XFILLER_88_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput59 _9084_/Q VGND VGND VPWR VPWR imAddr[28] sky130_fd_sc_hd__clkbuf_2
X_6349_ _6336_/X _6182_/Y _6336_/X _6182_/Y VGND VGND VPWR VPWR _6349_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_102_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9068_ _9069_/CLK _9068_/D repeater146/X VGND VGND VPWR VPWR _9068_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_69_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8019_ _8096_/Q _8064_/Q _8032_/Q _9024_/Q _5872_/C _5872_/B VGND VGND VPWR VPWR
+ _8019_/X sky130_fd_sc_hd__mux4_1
XFILLER_57_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_51_clk clkbuf_4_13_0_clk/X VGND VGND VPWR VPWR _8778_/CLK sky130_fd_sc_hd__clkbuf_16
XPHY_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3981_ _3981_/A VGND VGND VPWR VPWR _3982_/A sky130_fd_sc_hd__inv_2
XFILLER_63_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5720_ _8066_/Q _5714_/X _4659_/A _5715_/X VGND VGND VPWR VPWR _8066_/D sky130_fd_sc_hd__a22o_1
XFILLER_16_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_42_clk clkbuf_4_6_0_clk/X VGND VGND VPWR VPWR _9057_/CLK sky130_fd_sc_hd__clkbuf_16
X_5651_ _8113_/Q _5645_/X _5440_/X _5646_/X VGND VGND VPWR VPWR _8113_/D sky130_fd_sc_hd__a22o_1
XFILLER_31_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5582_ _5618_/A VGND VGND VPWR VPWR _5619_/A sky130_fd_sc_hd__inv_2
X_8370_ _9019_/CLK _8370_/D VGND VGND VPWR VPWR _8370_/Q sky130_fd_sc_hd__dfxtp_1
X_4602_ _4602_/A VGND VGND VPWR VPWR _4602_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_129_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4533_ _8771_/Q _4528_/X _4382_/X _4529_/X VGND VGND VPWR VPWR _8771_/D sky130_fd_sc_hd__a22o_1
X_7321_ _7317_/X _7318_/X _7319_/X _7320_/X _7341_/S0 _7336_/S1 VGND VGND VPWR VPWR
+ _7321_/X sky130_fd_sc_hd__mux4_2
X_7252_ _8818_/Q _8338_/Q _8946_/Q _8466_/Q _7359_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7252_/X sky130_fd_sc_hd__mux4_1
XFILLER_7_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6203_ _6203_/A VGND VGND VPWR VPWR _6203_/Y sky130_fd_sc_hd__inv_2
X_4464_ _8817_/Q _4458_/X _4348_/X _4459_/X VGND VGND VPWR VPWR _8817_/D sky130_fd_sc_hd__a22o_1
X_7183_ _8427_/Q _8299_/Q _8363_/Q _8555_/Q _7185_/S0 _7185_/S1 VGND VGND VPWR VPWR
+ _7183_/X sky130_fd_sc_hd__mux4_2
X_4395_ _4431_/A VGND VGND VPWR VPWR _4410_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_98_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6134_ _6246_/A _6134_/B VGND VGND VPWR VPWR _6145_/C sky130_fd_sc_hd__or2_1
XFILLER_133_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6065_ _6065_/A _6065_/B VGND VGND VPWR VPWR _6065_/Y sky130_fd_sc_hd__nor2_1
XFILLER_85_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater142 _7550_/S0 VGND VGND VPWR VPWR _7608_/S0 sky130_fd_sc_hd__buf_8
XFILLER_100_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater120 input9/X VGND VGND VPWR VPWR _8009_/S1 sky130_fd_sc_hd__buf_8
XFILLER_85_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater153 input36/X VGND VGND VPWR VPWR _7381_/S1 sky130_fd_sc_hd__buf_8
X_5016_ _8494_/Q _5012_/X _4904_/X _5013_/X VGND VGND VPWR VPWR _8494_/D sky130_fd_sc_hd__a22o_1
Xrepeater131 _7885_/S0 VGND VGND VPWR VPWR _7808_/S0 sky130_fd_sc_hd__buf_8
Xrepeater175 _7210_/S1 VGND VGND VPWR VPWR _7180_/S1 sky130_fd_sc_hd__buf_8
Xrepeater164 _7210_/S1 VGND VGND VPWR VPWR _7135_/S1 sky130_fd_sc_hd__buf_8
Xrepeater186 _7389_/S0 VGND VGND VPWR VPWR _7369_/S0 sky130_fd_sc_hd__buf_8
XFILLER_26_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater197 _7229_/S0 VGND VGND VPWR VPWR _7215_/S0 sky130_fd_sc_hd__clkbuf_8
XFILLER_26_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6967_ _7009_/X _7012_/X _6974_/S VGND VGND VPWR VPWR _6967_/X sky130_fd_sc_hd__mux2_1
X_8706_ _8709_/CLK _8706_/D VGND VGND VPWR VPWR _8706_/Q sky130_fd_sc_hd__dfxtp_1
X_5918_ _5918_/A _6951_/X VGND VGND VPWR VPWR _6570_/B sky130_fd_sc_hd__or2_1
XFILLER_41_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_33_clk clkbuf_4_7_0_clk/X VGND VGND VPWR VPWR _8873_/CLK sky130_fd_sc_hd__clkbuf_16
X_6898_ _6974_/X _6973_/X _6971_/S VGND VGND VPWR VPWR _6898_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8637_ _8734_/CLK _8637_/D VGND VGND VPWR VPWR _8637_/Q sky130_fd_sc_hd__dfxtp_1
X_5849_ _5870_/A _5849_/B VGND VGND VPWR VPWR _5849_/Y sky130_fd_sc_hd__nor2_1
XFILLER_42_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8568_ _8954_/CLK _8568_/D VGND VGND VPWR VPWR _8568_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_108_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7519_ _8103_/Q _8071_/Q _8039_/Q _9031_/Q _7599_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7519_/X sky130_fd_sc_hd__mux4_2
XFILLER_5_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8499_ _8786_/CLK _8499_/D VGND VGND VPWR VPWR _8499_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_123_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_91_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_2_3_0_clk clkbuf_2_3_0_clk/A VGND VGND VPWR VPWR clkbuf_3_7_0_clk/A sky130_fd_sc_hd__clkbuf_1
XFILLER_45_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_24_clk clkbuf_4_5_0_clk/X VGND VGND VPWR VPWR _8959_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_60_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4180_ _8981_/Q _4178_/X _4032_/X _4179_/X VGND VGND VPWR VPWR _8981_/D sky130_fd_sc_hd__a22o_1
XFILLER_122_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7870_ _8984_/Q _8408_/Q _8184_/Q _8760_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7870_/X sky130_fd_sc_hd__mux4_1
XFILLER_63_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6821_ _6600_/X _7048_/X _6830_/S VGND VGND VPWR VPWR _6821_/X sky130_fd_sc_hd__mux2_1
X_6752_ _6408_/X _6271_/Y _6777_/S VGND VGND VPWR VPWR _9062_/D sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_15_clk clkbuf_4_6_0_clk/X VGND VGND VPWR VPWR _9055_/CLK sky130_fd_sc_hd__clkbuf_16
X_6683_ _6682_/X _9056_/Q _6741_/S VGND VGND VPWR VPWR _6683_/X sky130_fd_sc_hd__mux2_2
X_5703_ _8079_/Q _5700_/X _4629_/A _5701_/X VGND VGND VPWR VPWR _8079_/D sky130_fd_sc_hd__a22o_1
X_8422_ _8710_/CLK _8422_/D VGND VGND VPWR VPWR _8422_/Q sky130_fd_sc_hd__dfxtp_1
X_5634_ _8126_/Q _5629_/X _5410_/X _5632_/X VGND VGND VPWR VPWR _8126_/D sky130_fd_sc_hd__a22o_1
X_8353_ _8926_/CLK _8353_/D VGND VGND VPWR VPWR _8353_/Q sky130_fd_sc_hd__dfxtp_1
X_5565_ _8171_/Q _5563_/X _5455_/X _5564_/X VGND VGND VPWR VPWR _8171_/D sky130_fd_sc_hd__a22o_1
X_7304_ _8535_/Q _8919_/Q _8855_/Q _8887_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7304_/X sky130_fd_sc_hd__mux4_2
XFILLER_105_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8284_ _9020_/CLK _8284_/D VGND VGND VPWR VPWR _8284_/Q sky130_fd_sc_hd__dfxtp_1
X_5496_ _8218_/Q _5494_/X _5419_/X _5495_/X VGND VGND VPWR VPWR _8218_/D sky130_fd_sc_hd__a22o_1
X_4516_ _8784_/Q _4514_/X _4351_/X _4515_/X VGND VGND VPWR VPWR _8784_/D sky130_fd_sc_hd__a22o_1
X_4447_ _8830_/Q _4442_/X _4318_/X _4445_/X VGND VGND VPWR VPWR _8830_/D sky130_fd_sc_hd__a22o_1
X_7235_ _8720_/Q _8688_/Q _8656_/Q _8624_/Q input33/X input34/X VGND VGND VPWR VPWR
+ _7235_/X sky130_fd_sc_hd__mux4_2
XFILLER_132_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7166_ _7162_/X _7163_/X _7164_/X _7165_/X _7391_/S0 _7381_/S1 VGND VGND VPWR VPWR
+ _7166_/X sky130_fd_sc_hd__mux4_2
XFILLER_86_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4378_ _4653_/A VGND VGND VPWR VPWR _4378_/X sky130_fd_sc_hd__clkbuf_2
X_6117_ _6117_/A VGND VGND VPWR VPWR _6513_/D sky130_fd_sc_hd__inv_2
X_7097_ _8578_/Q _8130_/Q _8482_/Q _8770_/Q _7130_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7097_/X sky130_fd_sc_hd__mux4_1
XFILLER_86_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6048_ _7003_/X _5849_/B _7006_/X _6101_/B _6047_/X VGND VGND VPWR VPWR _6048_/Y
+ sky130_fd_sc_hd__o221ai_1
XFILLER_37_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7999_ _8127_/Q _8095_/Q _8063_/Q _9055_/Q _8000_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7999_/X sky130_fd_sc_hd__mux4_2
XFILLER_14_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5350_ _8292_/Q _5346_/X _5200_/X _5347_/X VGND VGND VPWR VPWR _8292_/D sky130_fd_sc_hd__a22o_1
XFILLER_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4301_ _8903_/Q _4295_/X _4080_/X _4296_/X VGND VGND VPWR VPWR _8903_/D sky130_fd_sc_hd__a22o_1
XFILLER_99_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5281_ _8339_/Q _5277_/X _5164_/X _5278_/X VGND VGND VPWR VPWR _8339_/D sky130_fd_sc_hd__a22o_1
XFILLER_114_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7020_ _7696_/X _7701_/X _7020_/S VGND VGND VPWR VPWR _7020_/X sky130_fd_sc_hd__mux2_2
X_4232_ _8949_/Q _4230_/X _4032_/X _4231_/X VGND VGND VPWR VPWR _8949_/D sky130_fd_sc_hd__a22o_1
XFILLER_101_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_4_clk clkbuf_4_1_0_clk/X VGND VGND VPWR VPWR _8786_/CLK sky130_fd_sc_hd__clkbuf_16
X_4163_ _4199_/A VGND VGND VPWR VPWR _4200_/A sky130_fd_sc_hd__inv_2
X_8971_ _9031_/CLK _8971_/D VGND VGND VPWR VPWR _8971_/Q sky130_fd_sc_hd__dfxtp_1
X_4094_ _4657_/A VGND VGND VPWR VPWR _4094_/X sky130_fd_sc_hd__clkbuf_2
X_7922_ _8827_/Q _8347_/Q _8955_/Q _8475_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _7922_/X sky130_fd_sc_hd__mux4_2
XFILLER_55_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7853_ _8440_/Q _8312_/Q _8376_/Q _8568_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7853_/X sky130_fd_sc_hd__mux4_1
XFILLER_36_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4996_ _8508_/Q _4989_/X _4870_/X _4992_/X VGND VGND VPWR VPWR _8508_/D sky130_fd_sc_hd__a22o_1
XFILLER_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6804_ _6587_/Y _6596_/Y _6809_/S VGND VGND VPWR VPWR _6804_/X sky130_fd_sc_hd__mux2_4
X_7784_ _8532_/Q _8916_/Q _8852_/Q _8884_/Q _7949_/S0 input9/X VGND VGND VPWR VPWR
+ _7784_/X sky130_fd_sc_hd__mux4_1
XPHY_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6735_ _6734_/X _9082_/Q _6735_/S VGND VGND VPWR VPWR _6735_/X sky130_fd_sc_hd__mux2_1
X_6666_ _6666_/A _6666_/B VGND VGND VPWR VPWR _6666_/Y sky130_fd_sc_hd__nor2_1
X_5617_ _8135_/Q _5611_/X _5464_/X _5612_/X VGND VGND VPWR VPWR _8135_/D sky130_fd_sc_hd__a22o_1
X_6597_ _6550_/D _6550_/B _6549_/A _6490_/A VGND VGND VPWR VPWR _6597_/X sky130_fd_sc_hd__o22a_1
X_8405_ _9013_/CLK _8405_/D VGND VGND VPWR VPWR _8405_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_133_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5548_ _8182_/Q _5542_/X _5428_/X _5543_/X VGND VGND VPWR VPWR _8182_/D sky130_fd_sc_hd__a22o_1
X_8336_ _8816_/CLK _8336_/D VGND VGND VPWR VPWR _8336_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_132_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8267_ _9033_/CLK _8267_/D VGND VGND VPWR VPWR _8267_/Q sky130_fd_sc_hd__dfxtp_1
X_5479_ _8225_/Q _5430_/A _5478_/X _5432_/A VGND VGND VPWR VPWR _8225_/D sky130_fd_sc_hd__a22o_1
X_7218_ _8270_/Q _8238_/Q _8206_/Q _9006_/Q _7229_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7218_/X sky130_fd_sc_hd__mux4_2
XFILLER_120_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8198_ _9028_/CLK _8198_/D VGND VGND VPWR VPWR _8198_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7149_ _8103_/Q _8071_/Q _8039_/Q _9031_/Q _7190_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7149_/X sky130_fd_sc_hd__mux4_2
XFILLER_104_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4850_ _4850_/A VGND VGND VPWR VPWR _4850_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_60_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4781_ _4781_/A VGND VGND VPWR VPWR _4781_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_20_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6520_ _6520_/A VGND VGND VPWR VPWR _6677_/B sky130_fd_sc_hd__inv_2
XFILLER_9_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6451_ _7015_/X VGND VGND VPWR VPWR _6666_/A sky130_fd_sc_hd__inv_2
X_5402_ _8256_/Q _5373_/A _5208_/X _5374_/A VGND VGND VPWR VPWR _8256_/D sky130_fd_sc_hd__a22o_1
X_6382_ _6311_/A _6381_/X _6311_/A _6381_/X VGND VGND VPWR VPWR _6382_/Y sky130_fd_sc_hd__a2bb2oi_1
X_5333_ _5347_/A VGND VGND VPWR VPWR _5333_/X sky130_fd_sc_hd__clkbuf_2
X_8121_ _9080_/CLK _8121_/D VGND VGND VPWR VPWR _8121_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_126_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5264_ _5278_/A VGND VGND VPWR VPWR _5264_/X sky130_fd_sc_hd__buf_2
XFILLER_87_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8052_ _8981_/CLK _8052_/D VGND VGND VPWR VPWR _8052_/Q sky130_fd_sc_hd__dfxtp_1
X_5195_ _6784_/X VGND VGND VPWR VPWR _5195_/X sky130_fd_sc_hd__clkbuf_2
X_4215_ _4251_/A VGND VGND VPWR VPWR _4252_/A sky130_fd_sc_hd__inv_2
X_7003_ _5876_/Y _6251_/A _7069_/S VGND VGND VPWR VPWR _7003_/X sky130_fd_sc_hd__mux2_4
X_4146_ _9000_/Q _4141_/X _4077_/X _4142_/X VGND VGND VPWR VPWR _9000_/D sky130_fd_sc_hd__a22o_1
XFILLER_83_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4077_ _4645_/A VGND VGND VPWR VPWR _4077_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_83_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8954_ _8954_/CLK _8954_/D VGND VGND VPWR VPWR _8954_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_83_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8885_ _8945_/CLK _8885_/D VGND VGND VPWR VPWR _8885_/Q sky130_fd_sc_hd__dfxtp_1
X_7905_ _8730_/Q _8698_/Q _8666_/Q _8634_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7905_/X sky130_fd_sc_hd__mux4_2
X_7836_ _7832_/X _7833_/X _7834_/X _7835_/X _7901_/S0 _8031_/S1 VGND VGND VPWR VPWR
+ _7836_/X sky130_fd_sc_hd__mux4_1
XPHY_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4979_ _4979_/A VGND VGND VPWR VPWR _4979_/X sky130_fd_sc_hd__clkbuf_2
XPHY_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7767_ _8595_/Q _8147_/Q _8499_/Q _8787_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7767_/X sky130_fd_sc_hd__mux4_1
XPHY_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6718_ _7256_/X _7261_/X _6734_/S VGND VGND VPWR VPWR _6718_/X sky130_fd_sc_hd__mux2_2
XFILLER_7_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7698_ _8272_/Q _8240_/Q _8208_/Q _9008_/Q input14/X _7700_/S1 VGND VGND VPWR VPWR
+ _7698_/X sky130_fd_sc_hd__mux4_1
XFILLER_137_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6649_ _6454_/A _6008_/X _6621_/X VGND VGND VPWR VPWR _6649_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_137_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8319_ _8735_/CLK _8319_/D VGND VGND VPWR VPWR _8319_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_105_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4000_ _4593_/A VGND VGND VPWR VPWR _4000_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_93_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5951_ _6105_/A VGND VGND VPWR VPWR _5951_/X sky130_fd_sc_hd__buf_1
XFILLER_65_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8670_ _8734_/CLK _8670_/D VGND VGND VPWR VPWR _8670_/Q sky130_fd_sc_hd__dfxtp_1
X_4902_ _6793_/X VGND VGND VPWR VPWR _4902_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_33_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5882_ _5882_/A _5882_/B VGND VGND VPWR VPWR _5882_/Y sky130_fd_sc_hd__nor2_1
XFILLER_61_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7621_ _7617_/X _7618_/X _7619_/X _7620_/X _7701_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7621_/X sky130_fd_sc_hd__mux4_1
XFILLER_61_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4833_ _8594_/Q _4828_/X _4621_/X _4829_/X VGND VGND VPWR VPWR _8594_/D sky130_fd_sc_hd__a22o_1
X_7552_ _8809_/Q _8329_/Q _8937_/Q _8457_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7552_/X sky130_fd_sc_hd__mux4_1
X_4764_ _4780_/A VGND VGND VPWR VPWR _4764_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_21_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7483_ _8421_/Q _8293_/Q _8357_/Q _8549_/Q _7505_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7483_/X sky130_fd_sc_hd__mux4_1
X_6503_ _6824_/X VGND VGND VPWR VPWR _6503_/Y sky130_fd_sc_hd__inv_2
XFILLER_119_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4695_ _8686_/Q _4691_/X _4631_/X _4692_/X VGND VGND VPWR VPWR _8686_/D sky130_fd_sc_hd__a22o_1
X_6434_ _6434_/A VGND VGND VPWR VPWR _6434_/X sky130_fd_sc_hd__buf_1
XFILLER_106_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6365_ _6214_/B _6364_/X _6214_/B _6364_/X VGND VGND VPWR VPWR _6365_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_130_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5316_ _8316_/Q _5309_/X _5142_/X _5312_/X VGND VGND VPWR VPWR _8316_/D sky130_fd_sc_hd__a22o_1
X_8104_ _9061_/CLK _8104_/D VGND VGND VPWR VPWR _8104_/Q sky130_fd_sc_hd__dfxtp_1
X_6296_ _6415_/A _6415_/B _6416_/B _6295_/Y VGND VGND VPWR VPWR _6297_/C sky130_fd_sc_hd__o22a_2
XFILLER_0_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9084_ _9086_/CLK _9084_/D repeater147/X VGND VGND VPWR VPWR _9084_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_130_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5247_ _8361_/Q _5243_/X _5188_/X _5244_/X VGND VGND VPWR VPWR _8361_/D sky130_fd_sc_hd__a22o_1
XFILLER_102_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8035_ _9027_/CLK _8035_/D VGND VGND VPWR VPWR _8035_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_76_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5178_ _6791_/X VGND VGND VPWR VPWR _5178_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_56_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4129_ _9013_/Q _4127_/X _4032_/X _4128_/X VGND VGND VPWR VPWR _9013_/D sky130_fd_sc_hd__a22o_1
X_8937_ _8938_/CLK _8937_/D VGND VGND VPWR VPWR _8937_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_83_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8868_ _8868_/CLK _8868_/D VGND VGND VPWR VPWR _8868_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8799_ _8959_/CLK _8799_/D VGND VGND VPWR VPWR _8799_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_61_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7819_ _8118_/Q _8086_/Q _8054_/Q _9046_/Q input14/X _7900_/S1 VGND VGND VPWR VPWR
+ _7819_/X sky130_fd_sc_hd__mux4_2
XPHY_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4480_ _4480_/A VGND VGND VPWR VPWR _4480_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_7_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6150_ _6150_/A VGND VGND VPWR VPWR _6151_/B sky130_fd_sc_hd__inv_2
XFILLER_111_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5101_ _5101_/A VGND VGND VPWR VPWR _5101_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_112_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6081_ _5900_/A _5793_/A _6976_/X _5947_/B _6080_/Y VGND VGND VPWR VPWR _6084_/B
+ sky130_fd_sc_hd__a221o_1
X_5032_ _8482_/Q _5026_/X _4932_/X _5027_/X VGND VGND VPWR VPWR _8482_/D sky130_fd_sc_hd__a22o_1
X_6983_ _7446_/X _7451_/X _7022_/S VGND VGND VPWR VPWR _6983_/X sky130_fd_sc_hd__mux2_1
XFILLER_81_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5934_ _6897_/X _6061_/B _5933_/Y _5812_/A VGND VGND VPWR VPWR _5934_/X sky130_fd_sc_hd__o22a_1
X_8722_ _8882_/CLK _8722_/D VGND VGND VPWR VPWR _8722_/Q sky130_fd_sc_hd__dfxtp_1
X_5865_ _5890_/A _5870_/D VGND VGND VPWR VPWR _5866_/B sky130_fd_sc_hd__or2_1
X_8653_ _8876_/CLK _8653_/D VGND VGND VPWR VPWR _8653_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_61_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7604_ _8523_/Q _8907_/Q _8843_/Q _8875_/Q _7604_/S0 _7604_/S1 VGND VGND VPWR VPWR
+ _7604_/X sky130_fd_sc_hd__mux4_1
X_4816_ _8607_/Q _4812_/X _4668_/X _4815_/X VGND VGND VPWR VPWR _8607_/D sky130_fd_sc_hd__a22o_1
X_8584_ _8939_/CLK _8584_/D VGND VGND VPWR VPWR _8584_/Q sky130_fd_sc_hd__dfxtp_1
X_5796_ _6868_/X _5908_/B _5790_/Y _5795_/A VGND VGND VPWR VPWR _5797_/B sky130_fd_sc_hd__a22o_1
X_7535_ _8712_/Q _8680_/Q _8648_/Q _8616_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7535_/X sky130_fd_sc_hd__mux4_2
X_4747_ _4754_/A VGND VGND VPWR VPWR _4747_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_134_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7466_ _7462_/X _7463_/X _7464_/X _7465_/X _7611_/S0 _7611_/S1 VGND VGND VPWR VPWR
+ _7466_/X sky130_fd_sc_hd__mux4_2
X_4678_ _4685_/A VGND VGND VPWR VPWR _4678_/X sky130_fd_sc_hd__clkbuf_2
X_6417_ _6416_/A _6416_/B _6295_/Y _6295_/A _6416_/Y VGND VGND VPWR VPWR _6417_/X
+ sky130_fd_sc_hd__o32a_1
X_7397_ _8577_/Q _8129_/Q _8481_/Q _8769_/Q _5771_/A _5772_/B VGND VGND VPWR VPWR
+ _7397_/X sky130_fd_sc_hd__mux4_1
Xoutput49 _9075_/Q VGND VGND VPWR VPWR imAddr[19] sky130_fd_sc_hd__clkbuf_2
X_6348_ _6105_/X _7064_/X VGND VGND VPWR VPWR _6348_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_0_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6279_ _5953_/A _6278_/Y _5953_/Y _6278_/A VGND VGND VPWR VPWR _6297_/B sky130_fd_sc_hd__a22o_2
XFILLER_76_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9067_ _9067_/CLK _9067_/D repeater146/X VGND VGND VPWR VPWR _9067_/Q sky130_fd_sc_hd__dfrtp_2
X_8018_ _8256_/Q _8224_/Q _8192_/Q _8992_/Q _5872_/C _5872_/B VGND VGND VPWR VPWR
+ _8018_/X sky130_fd_sc_hd__mux4_2
XFILLER_29_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3980_ _3980_/A VGND VGND VPWR VPWR _6288_/A sky130_fd_sc_hd__inv_2
XFILLER_63_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clkbuf_0_clk/X sky130_fd_sc_hd__clkbuf_16
X_5650_ _8114_/Q _5645_/X _5438_/X _5646_/X VGND VGND VPWR VPWR _8114_/D sky130_fd_sc_hd__a22o_1
XFILLER_31_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4601_ _4613_/A VGND VGND VPWR VPWR _4601_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_129_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5581_ _5597_/A VGND VGND VPWR VPWR _5581_/X sky130_fd_sc_hd__clkbuf_2
X_4532_ _8772_/Q _4528_/X _4380_/X _4529_/X VGND VGND VPWR VPWR _8772_/D sky130_fd_sc_hd__a22o_1
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7320_ _8984_/Q _8408_/Q _8184_/Q _8760_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7320_/X sky130_fd_sc_hd__mux4_1
X_4463_ _8818_/Q _4458_/X _4346_/X _4459_/X VGND VGND VPWR VPWR _8818_/D sky130_fd_sc_hd__a22o_1
X_7251_ _7247_/X _7248_/X _7249_/X _7250_/X _7291_/S0 input36/X VGND VGND VPWR VPWR
+ _7251_/X sky130_fd_sc_hd__mux4_2
XFILLER_116_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6202_ _9075_/Q _6153_/B _6154_/C VGND VGND VPWR VPWR _6203_/A sky130_fd_sc_hd__o21ai_2
X_7182_ _8811_/Q _8331_/Q _8939_/Q _8459_/Q _7184_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7182_/X sky130_fd_sc_hd__mux4_2
X_4394_ _4430_/A VGND VGND VPWR VPWR _4431_/A sky130_fd_sc_hd__clkinv_4
XFILLER_131_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6133_ _9067_/Q VGND VGND VPWR VPWR _6134_/B sky130_fd_sc_hd__inv_2
XFILLER_112_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6064_ _5927_/A _5812_/A _5944_/A _5815_/A _6063_/Y VGND VGND VPWR VPWR _6065_/B
+ sky130_fd_sc_hd__o221a_1
Xrepeater110 _7909_/S1 VGND VGND VPWR VPWR _7910_/S1 sky130_fd_sc_hd__buf_8
Xrepeater143 _7550_/S0 VGND VGND VPWR VPWR _8005_/S0 sky130_fd_sc_hd__buf_8
X_5015_ _8495_/Q _5012_/X _4902_/X _5013_/X VGND VGND VPWR VPWR _8495_/D sky130_fd_sc_hd__a22o_1
Xrepeater132 _7907_/S0 VGND VGND VPWR VPWR _7885_/S0 sky130_fd_sc_hd__buf_8
Xrepeater121 _7904_/S1 VGND VGND VPWR VPWR _7905_/S1 sky130_fd_sc_hd__buf_6
XFILLER_39_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater176 _7219_/S1 VGND VGND VPWR VPWR _7210_/S1 sky130_fd_sc_hd__buf_8
XFILLER_54_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrepeater165 _7334_/S1 VGND VGND VPWR VPWR _7335_/S1 sky130_fd_sc_hd__buf_6
Xrepeater154 _7336_/S1 VGND VGND VPWR VPWR _7341_/S1 sky130_fd_sc_hd__buf_8
XFILLER_39_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrepeater187 _7359_/S0 VGND VGND VPWR VPWR _7389_/S0 sky130_fd_sc_hd__buf_8
XFILLER_53_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater198 _7240_/S0 VGND VGND VPWR VPWR _7229_/S0 sky130_fd_sc_hd__buf_8
X_6966_ _7015_/X _7018_/X _6974_/S VGND VGND VPWR VPWR _6966_/X sky130_fd_sc_hd__mux2_1
X_5917_ _6971_/S VGND VGND VPWR VPWR _5917_/Y sky130_fd_sc_hd__inv_2
X_8705_ _8929_/CLK _8705_/D VGND VGND VPWR VPWR _8705_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6897_ _5932_/X _6982_/X _6943_/S VGND VGND VPWR VPWR _6897_/X sky130_fd_sc_hd__mux2_2
X_8636_ _8735_/CLK _8636_/D VGND VGND VPWR VPWR _8636_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5848_ _5848_/A VGND VGND VPWR VPWR _5849_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_139_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5779_ _6999_/X _6040_/B VGND VGND VPWR VPWR _5780_/A sky130_fd_sc_hd__and2_1
XFILLER_6_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8567_ _8665_/CLK _8567_/D VGND VGND VPWR VPWR _8567_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_108_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7518_ _8263_/Q _8231_/Q _8199_/Q _8999_/Q _7599_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7518_/X sky130_fd_sc_hd__mux4_1
XFILLER_107_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8498_ _8786_/CLK _8498_/D VGND VGND VPWR VPWR _8498_/Q sky130_fd_sc_hd__dfxtp_1
X_7449_ _8099_/Q _8067_/Q _8035_/Q _9027_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7449_/X sky130_fd_sc_hd__mux4_1
XFILLER_131_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6820_ _6595_/X _7051_/X _6830_/S VGND VGND VPWR VPWR _6820_/X sky130_fd_sc_hd__mux2_1
XFILLER_36_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6751_ _6407_/Y _6274_/Y _6777_/S VGND VGND VPWR VPWR _9061_/D sky130_fd_sc_hd__mux2_1
XFILLER_51_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6682_ _7076_/X _7081_/X _6744_/S VGND VGND VPWR VPWR _6682_/X sky130_fd_sc_hd__mux2_1
X_5702_ _8080_/Q _5700_/X _4626_/A _5701_/X VGND VGND VPWR VPWR _8080_/D sky130_fd_sc_hd__a22o_1
X_8421_ _8709_/CLK _8421_/D VGND VGND VPWR VPWR _8421_/Q sky130_fd_sc_hd__dfxtp_1
X_5633_ _8127_/Q _5629_/X _5485_/X _5632_/X VGND VGND VPWR VPWR _8127_/D sky130_fd_sc_hd__a22o_1
X_5564_ _5571_/A VGND VGND VPWR VPWR _5564_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_129_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8352_ _8928_/CLK _8352_/D VGND VGND VPWR VPWR _8352_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4515_ _4529_/A VGND VGND VPWR VPWR _4515_/X sky130_fd_sc_hd__buf_2
X_7303_ _8439_/Q _8311_/Q _8375_/Q _8567_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7303_/X sky130_fd_sc_hd__mux4_1
XFILLER_117_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8283_ _9020_/CLK _8283_/D VGND VGND VPWR VPWR _8283_/Q sky130_fd_sc_hd__dfxtp_1
X_5495_ _5502_/A VGND VGND VPWR VPWR _5495_/X sky130_fd_sc_hd__clkbuf_2
X_4446_ _8831_/Q _4442_/X _4393_/X _4445_/X VGND VGND VPWR VPWR _8831_/D sky130_fd_sc_hd__a22o_1
X_7234_ _8528_/Q _8912_/Q _8848_/Q _8880_/Q _7240_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7234_/X sky130_fd_sc_hd__mux4_1
X_7165_ _8713_/Q _8681_/Q _8649_/Q _8617_/Q _7185_/S0 _7185_/S1 VGND VGND VPWR VPWR
+ _7165_/X sky130_fd_sc_hd__mux4_1
XFILLER_120_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4377_ _8870_/Q _4374_/X _4375_/X _4376_/X VGND VGND VPWR VPWR _8870_/D sky130_fd_sc_hd__a22o_1
XFILLER_113_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6116_ _6848_/X _5849_/B _5778_/A _5837_/Y VGND VGND VPWR VPWR _6118_/A sky130_fd_sc_hd__a22o_1
XFILLER_58_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7096_ _7092_/X _7093_/X _7094_/X _7095_/X input35/X _7191_/S1 VGND VGND VPWR VPWR
+ _7096_/X sky130_fd_sc_hd__mux4_2
XFILLER_112_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6047_ _7003_/X _5849_/B _7000_/X _5882_/B _6046_/X VGND VGND VPWR VPWR _6047_/X
+ sky130_fd_sc_hd__a221o_1
XFILLER_73_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7998_ _8287_/Q _8255_/Q _8223_/Q _9023_/Q _8000_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7998_/X sky130_fd_sc_hd__mux4_1
X_6949_ _6957_/X _6950_/X _6949_/S VGND VGND VPWR VPWR _6949_/X sky130_fd_sc_hd__mux2_2
XFILLER_53_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8619_ _8873_/CLK _8619_/D VGND VGND VPWR VPWR _8619_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4300_ _8904_/Q _4295_/X _4077_/X _4296_/X VGND VGND VPWR VPWR _8904_/D sky130_fd_sc_hd__a22o_1
X_5280_ _8340_/Q _5277_/X _5162_/X _5278_/X VGND VGND VPWR VPWR _8340_/D sky130_fd_sc_hd__a22o_1
XFILLER_102_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4231_ _4231_/A VGND VGND VPWR VPWR _4231_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_95_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4162_ _4178_/A VGND VGND VPWR VPWR _4162_/X sky130_fd_sc_hd__clkbuf_2
X_8970_ _8970_/CLK _8970_/D VGND VGND VPWR VPWR _8970_/Q sky130_fd_sc_hd__dfxtp_1
X_4093_ _6781_/X VGND VGND VPWR VPWR _4657_/A sky130_fd_sc_hd__clkbuf_2
X_7921_ _7917_/X _7918_/X _7919_/X _7920_/X _8031_/S0 _8001_/S1 VGND VGND VPWR VPWR
+ _7921_/X sky130_fd_sc_hd__mux4_1
XFILLER_24_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7852_ _8824_/Q _8344_/Q _8952_/Q _8472_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7852_/X sky130_fd_sc_hd__mux4_1
XFILLER_90_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4995_ _8509_/Q _4989_/X _4868_/X _4992_/X VGND VGND VPWR VPWR _8509_/D sky130_fd_sc_hd__a22o_1
XFILLER_63_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6803_ _6594_/Y _6603_/X _6809_/S VGND VGND VPWR VPWR _6803_/X sky130_fd_sc_hd__mux2_4
X_7783_ _8436_/Q _8308_/Q _8372_/Q _8564_/Q _7949_/S0 input9/X VGND VGND VPWR VPWR
+ _7783_/X sky130_fd_sc_hd__mux4_2
XPHY_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6734_ _7336_/X _7341_/X _6734_/S VGND VGND VPWR VPWR _6734_/X sky130_fd_sc_hd__mux2_1
XFILLER_23_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6665_ _6835_/X _5946_/X _6100_/X _6664_/Y VGND VGND VPWR VPWR _6665_/Y sky130_fd_sc_hd__o22ai_1
X_8404_ _9012_/CLK _8404_/D VGND VGND VPWR VPWR _8404_/Q sky130_fd_sc_hd__dfxtp_1
X_5616_ _8136_/Q _5611_/X _5462_/X _5612_/X VGND VGND VPWR VPWR _8136_/D sky130_fd_sc_hd__a22o_1
X_6596_ _6481_/B _6589_/X _6481_/B _6589_/X VGND VGND VPWR VPWR _6596_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_3_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5547_ _8183_/Q _5542_/X _5426_/X _5543_/X VGND VGND VPWR VPWR _8183_/D sky130_fd_sc_hd__a22o_1
X_8335_ _8943_/CLK _8335_/D VGND VGND VPWR VPWR _8335_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_133_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8266_ _8586_/CLK _8266_/D VGND VGND VPWR VPWR _8266_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_105_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5478_ _6779_/X VGND VGND VPWR VPWR _5478_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_105_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4429_ _8839_/Q _4423_/X _4372_/X _4424_/X VGND VGND VPWR VPWR _8839_/D sky130_fd_sc_hd__a22o_1
X_7217_ _8590_/Q _8142_/Q _8494_/Q _8782_/Q _7229_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7217_/X sky130_fd_sc_hd__mux4_2
X_8197_ _8994_/CLK _8197_/D VGND VGND VPWR VPWR _8197_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_2_2_0_clk clkbuf_2_3_0_clk/A VGND VGND VPWR VPWR clkbuf_3_5_0_clk/A sky130_fd_sc_hd__clkbuf_1
X_7148_ _8263_/Q _8231_/Q _8199_/Q _8999_/Q _7184_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7148_/X sky130_fd_sc_hd__mux4_1
XFILLER_101_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7079_ _8096_/Q _8064_/Q _8032_/Q _9024_/Q _7369_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7079_/X sky130_fd_sc_hd__mux4_2
XFILLER_48_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4780_ _4780_/A VGND VGND VPWR VPWR _4780_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_60_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6450_ _7030_/X VGND VGND VPWR VPWR _6456_/A sky130_fd_sc_hd__inv_2
X_5401_ _8257_/Q _5373_/A _5206_/X _5374_/A VGND VGND VPWR VPWR _8257_/D sky130_fd_sc_hd__a22o_1
X_6381_ _6311_/B _6380_/X _6232_/X VGND VGND VPWR VPWR _6381_/X sky130_fd_sc_hd__o21a_1
XFILLER_115_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5332_ _5346_/A VGND VGND VPWR VPWR _5332_/X sky130_fd_sc_hd__clkbuf_2
X_8120_ _9048_/CLK _8120_/D VGND VGND VPWR VPWR _8120_/Q sky130_fd_sc_hd__dfxtp_1
X_5263_ _5299_/A VGND VGND VPWR VPWR _5278_/A sky130_fd_sc_hd__clkbuf_4
X_8051_ _9044_/CLK _8051_/D VGND VGND VPWR VPWR _8051_/Q sky130_fd_sc_hd__dfxtp_1
X_7002_ _7576_/X _7581_/X _7071_/S VGND VGND VPWR VPWR _7002_/X sky130_fd_sc_hd__mux2_2
X_5194_ _5194_/A VGND VGND VPWR VPWR _5194_/X sky130_fd_sc_hd__buf_2
X_4214_ _4230_/A VGND VGND VPWR VPWR _4214_/X sky130_fd_sc_hd__clkbuf_2
X_4145_ _9001_/Q _4141_/X _4074_/X _4142_/X VGND VGND VPWR VPWR _9001_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4076_ _6786_/X VGND VGND VPWR VPWR _4645_/A sky130_fd_sc_hd__clkbuf_2
X_8953_ _8953_/CLK _8953_/D VGND VGND VPWR VPWR _8953_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_52_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7904_ _8538_/Q _8922_/Q _8858_/Q _8890_/Q _7907_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7904_/X sky130_fd_sc_hd__mux4_1
XFILLER_36_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8884_ _8947_/CLK _8884_/D VGND VGND VPWR VPWR _8884_/Q sky130_fd_sc_hd__dfxtp_1
X_7835_ _8727_/Q _8695_/Q _8663_/Q _8631_/Q _7875_/S0 _7897_/S1 VGND VGND VPWR VPWR
+ _7835_/X sky130_fd_sc_hd__mux4_2
XPHY_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4978_ _4978_/A VGND VGND VPWR VPWR _4978_/X sky130_fd_sc_hd__clkbuf_2
XPHY_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7766_ _7762_/X _7763_/X _7764_/X _7765_/X _7811_/S0 _8021_/S1 VGND VGND VPWR VPWR
+ _7766_/X sky130_fd_sc_hd__mux4_1
X_7697_ _8592_/Q _8144_/Q _8496_/Q _8784_/Q _7697_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7697_/X sky130_fd_sc_hd__mux4_2
X_6717_ _6716_/X _9073_/Q _6733_/S VGND VGND VPWR VPWR _6717_/X sky130_fd_sc_hd__mux2_4
XFILLER_137_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6648_ _6501_/C _6647_/A _6497_/A _6647_/Y VGND VGND VPWR VPWR _6648_/X sky130_fd_sc_hd__o22a_1
XFILLER_137_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8318_ _8863_/CLK _8318_/D VGND VGND VPWR VPWR _8318_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_106_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6579_ _6463_/A _5988_/B _6438_/X VGND VGND VPWR VPWR _6579_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_133_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8249_ _8794_/CLK _8249_/D VGND VGND VPWR VPWR _8249_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_105_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5950_ _5827_/A _5827_/B _5828_/A VGND VGND VPWR VPWR _5950_/X sky130_fd_sc_hd__o21a_1
XFILLER_46_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4901_ _8560_/Q _4898_/X _4899_/X _4900_/X VGND VGND VPWR VPWR _8560_/D sky130_fd_sc_hd__a22o_1
X_7620_ _8972_/Q _8396_/Q _8172_/Q _8748_/Q _7659_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7620_/X sky130_fd_sc_hd__mux4_1
X_5881_ _5881_/A VGND VGND VPWR VPWR _5881_/X sky130_fd_sc_hd__buf_1
XFILLER_21_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4832_ _8595_/Q _4828_/X _4619_/X _4829_/X VGND VGND VPWR VPWR _8595_/D sky130_fd_sc_hd__a22o_1
XFILLER_33_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7551_ _7547_/X _7548_/X _7549_/X _7550_/X _7611_/S0 _7611_/S1 VGND VGND VPWR VPWR
+ _7551_/X sky130_fd_sc_hd__mux4_1
X_4763_ _4801_/A VGND VGND VPWR VPWR _4780_/A sky130_fd_sc_hd__clkbuf_4
X_7482_ _8805_/Q _8325_/Q _8933_/Q _8453_/Q _7505_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7482_/X sky130_fd_sc_hd__mux4_1
X_6502_ _6502_/A VGND VGND VPWR VPWR _6502_/Y sky130_fd_sc_hd__inv_2
X_4694_ _8687_/Q _4691_/X _4629_/X _4692_/X VGND VGND VPWR VPWR _8687_/D sky130_fd_sc_hd__a22o_1
X_6433_ _6433_/A _6433_/B VGND VGND VPWR VPWR _6434_/A sky130_fd_sc_hd__or2_1
XFILLER_115_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6364_ _6214_/A _6359_/X _6208_/X VGND VGND VPWR VPWR _6364_/X sky130_fd_sc_hd__o21a_1
X_5315_ _8317_/Q _5309_/X _5140_/X _5312_/X VGND VGND VPWR VPWR _8317_/D sky130_fd_sc_hd__a22o_1
X_8103_ _9031_/CLK _8103_/D VGND VGND VPWR VPWR _8103_/Q sky130_fd_sc_hd__dfxtp_1
X_6295_ _6295_/A VGND VGND VPWR VPWR _6295_/Y sky130_fd_sc_hd__inv_2
XFILLER_103_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9083_ _9086_/CLK _9083_/D repeater147/X VGND VGND VPWR VPWR _9083_/Q sky130_fd_sc_hd__dfrtp_2
X_5246_ _8362_/Q _5243_/X _5186_/X _5244_/X VGND VGND VPWR VPWR _8362_/D sky130_fd_sc_hd__a22o_1
X_8034_ _9029_/CLK _8034_/D VGND VGND VPWR VPWR _8034_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_88_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5177_ _8398_/Q _5170_/X _5176_/X _5172_/X VGND VGND VPWR VPWR _8398_/D sky130_fd_sc_hd__a22o_1
XFILLER_29_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4128_ _4128_/A VGND VGND VPWR VPWR _4128_/X sky130_fd_sc_hd__buf_2
X_8936_ _8939_/CLK _8936_/D VGND VGND VPWR VPWR _8936_/Q sky130_fd_sc_hd__dfxtp_1
X_4059_ _6791_/X VGND VGND VPWR VPWR _4633_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_45_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8867_ _8868_/CLK _8867_/D VGND VGND VPWR VPWR _8867_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8798_ _8926_/CLK _8798_/D VGND VGND VPWR VPWR _8798_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_51_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7818_ _8278_/Q _8246_/Q _8214_/Q _9014_/Q input14/X _7900_/S1 VGND VGND VPWR VPWR
+ _7818_/X sky130_fd_sc_hd__mux4_1
XFILLER_40_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7749_ _8114_/Q _8082_/Q _8050_/Q _9042_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7749_/X sky130_fd_sc_hd__mux4_2
XFILLER_117_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_2171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6080_ _5821_/Y _5822_/Y _5858_/B _5824_/Y VGND VGND VPWR VPWR _6080_/Y sky130_fd_sc_hd__o31ai_2
XFILLER_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5100_ _8438_/Q _5094_/X _4884_/X _5095_/X VGND VGND VPWR VPWR _8438_/D sky130_fd_sc_hd__a22o_1
X_5031_ _8483_/Q _5026_/X _4930_/X _5027_/X VGND VGND VPWR VPWR _8483_/D sky130_fd_sc_hd__a22o_1
XFILLER_97_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6982_ _6092_/Y _6415_/A _7069_/S VGND VGND VPWR VPWR _6982_/X sky130_fd_sc_hd__mux2_4
XFILLER_80_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8721_ _9051_/CLK _8721_/D VGND VGND VPWR VPWR _8721_/Q sky130_fd_sc_hd__dfxtp_1
X_5933_ _6897_/X VGND VGND VPWR VPWR _5933_/Y sky130_fd_sc_hd__inv_2
XFILLER_81_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8652_ _8876_/CLK _8652_/D VGND VGND VPWR VPWR _8652_/Q sky130_fd_sc_hd__dfxtp_1
X_5864_ _5900_/A _5864_/B VGND VGND VPWR VPWR _5870_/D sky130_fd_sc_hd__or2_2
XFILLER_61_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7603_ _8427_/Q _8299_/Q _8363_/Q _8555_/Q _7604_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7603_/X sky130_fd_sc_hd__mux4_2
X_8583_ _8939_/CLK _8583_/D VGND VGND VPWR VPWR _8583_/Q sky130_fd_sc_hd__dfxtp_1
X_4815_ _4829_/A VGND VGND VPWR VPWR _4815_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_21_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7534_ _8520_/Q _8904_/Q _8840_/Q _8872_/Q _7594_/S0 _5772_/B VGND VGND VPWR VPWR
+ _7534_/X sky130_fd_sc_hd__mux4_2
X_5795_ _5795_/A VGND VGND VPWR VPWR _5908_/B sky130_fd_sc_hd__inv_2
X_4746_ _4753_/A VGND VGND VPWR VPWR _4746_/X sky130_fd_sc_hd__clkbuf_2
X_7465_ _8708_/Q _8676_/Q _8644_/Q _8612_/Q _7610_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7465_/X sky130_fd_sc_hd__mux4_1
X_4677_ _4684_/A VGND VGND VPWR VPWR _4677_/X sky130_fd_sc_hd__clkbuf_2
X_6416_ _6416_/A _6416_/B VGND VGND VPWR VPWR _6416_/Y sky130_fd_sc_hd__nor2_1
XFILLER_134_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7396_ _7392_/X _7393_/X _7394_/X _7395_/X _5771_/C _5771_/B VGND VGND VPWR VPWR
+ _7396_/X sky130_fd_sc_hd__mux4_1
Xoutput39 _9056_/Q VGND VGND VPWR VPWR imAddr[0] sky130_fd_sc_hd__clkbuf_2
XFILLER_134_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6347_ _6337_/X _6339_/X _6337_/X _6339_/X VGND VGND VPWR VPWR _6347_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_88_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6278_ _6278_/A VGND VGND VPWR VPWR _6278_/Y sky130_fd_sc_hd__inv_2
X_9066_ _9067_/CLK _9066_/D repeater146/X VGND VGND VPWR VPWR _9066_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_130_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8017_ _8576_/Q _8128_/Q _8480_/Q _8768_/Q _5872_/C _5872_/B VGND VGND VPWR VPWR
+ _8017_/X sky130_fd_sc_hd__mux4_2
X_5229_ _5229_/A VGND VGND VPWR VPWR _5229_/X sky130_fd_sc_hd__buf_2
XFILLER_56_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8919_ _8951_/CLK _8919_/D VGND VGND VPWR VPWR _8919_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_25_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4600_ _8731_/Q _4588_/X _4599_/X _4591_/X VGND VGND VPWR VPWR _8731_/D sky130_fd_sc_hd__a22o_1
X_5580_ _5618_/A VGND VGND VPWR VPWR _5597_/A sky130_fd_sc_hd__buf_4
XPHY_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4531_ _8773_/Q _4528_/X _4378_/X _4529_/X VGND VGND VPWR VPWR _8773_/D sky130_fd_sc_hd__a22o_1
X_7250_ _8977_/Q _8401_/Q _8177_/Q _8753_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7250_/X sky130_fd_sc_hd__mux4_1
X_4462_ _8819_/Q _4458_/X _4344_/X _4459_/X VGND VGND VPWR VPWR _8819_/D sky130_fd_sc_hd__a22o_1
XFILLER_116_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6201_ _6201_/A VGND VGND VPWR VPWR _6201_/X sky130_fd_sc_hd__clkbuf_2
X_7181_ _7177_/X _7178_/X _7179_/X _7180_/X _7191_/S0 _7191_/S1 VGND VGND VPWR VPWR
+ _7181_/X sky130_fd_sc_hd__mux4_1
X_4393_ _4668_/A VGND VGND VPWR VPWR _4393_/X sky130_fd_sc_hd__clkbuf_2
X_6132_ _9066_/Q VGND VGND VPWR VPWR _6246_/A sky130_fd_sc_hd__inv_2
XFILLER_112_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6063_ _6976_/X _5947_/B _5943_/A _5944_/B _6062_/X VGND VGND VPWR VPWR _6063_/Y
+ sky130_fd_sc_hd__o221ai_1
XFILLER_58_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater144 _7604_/S0 VGND VGND VPWR VPWR _7550_/S0 sky130_fd_sc_hd__clkbuf_8
X_5014_ _8496_/Q _5012_/X _4899_/X _5013_/X VGND VGND VPWR VPWR _8496_/D sky130_fd_sc_hd__a22o_1
Xrepeater122 _7808_/S1 VGND VGND VPWR VPWR _7904_/S1 sky130_fd_sc_hd__clkbuf_8
Xrepeater133 _7910_/S0 VGND VGND VPWR VPWR _7907_/S0 sky130_fd_sc_hd__buf_6
Xrepeater111 _6099_/A VGND VGND VPWR VPWR _7909_/S1 sky130_fd_sc_hd__buf_8
Xrepeater177 _7240_/S1 VGND VGND VPWR VPWR _7219_/S1 sky130_fd_sc_hd__buf_8
Xrepeater166 _7288_/S1 VGND VGND VPWR VPWR _7334_/S1 sky130_fd_sc_hd__buf_8
Xrepeater155 input36/X VGND VGND VPWR VPWR _7336_/S1 sky130_fd_sc_hd__buf_6
XFILLER_38_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater188 _7390_/S0 VGND VGND VPWR VPWR _7359_/S0 sky130_fd_sc_hd__buf_8
XFILLER_66_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater199 _7240_/S0 VGND VGND VPWR VPWR _7339_/S0 sky130_fd_sc_hd__buf_4
X_6965_ _6967_/X _6966_/X _6971_/S VGND VGND VPWR VPWR _6965_/X sky130_fd_sc_hd__mux2_1
XFILLER_54_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5916_ _5908_/A _5863_/B _5864_/B VGND VGND VPWR VPWR _5916_/X sky130_fd_sc_hd__a21bo_1
X_8704_ _9054_/CLK _8704_/D VGND VGND VPWR VPWR _8704_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_41_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8635_ _8735_/CLK _8635_/D VGND VGND VPWR VPWR _8635_/Q sky130_fd_sc_hd__dfxtp_1
X_6896_ _6940_/X _6938_/X _6939_/S VGND VGND VPWR VPWR _6896_/X sky130_fd_sc_hd__mux2_1
XFILLER_34_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5847_ _7003_/X VGND VGND VPWR VPWR _5870_/A sky130_fd_sc_hd__inv_2
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5778_ _5778_/A VGND VGND VPWR VPWR _6513_/C sky130_fd_sc_hd__inv_2
X_8566_ _8822_/CLK _8566_/D VGND VGND VPWR VPWR _8566_/Q sky130_fd_sc_hd__dfxtp_1
X_7517_ _8583_/Q _8135_/Q _8487_/Q _8775_/Q _7599_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7517_/X sky130_fd_sc_hd__mux4_1
X_4729_ _8664_/Q _4725_/X _4607_/X _4726_/X VGND VGND VPWR VPWR _8664_/D sky130_fd_sc_hd__a22o_1
X_8497_ _9013_/CLK _8497_/D VGND VGND VPWR VPWR _8497_/Q sky130_fd_sc_hd__dfxtp_1
X_7448_ _8259_/Q _8227_/Q _8195_/Q _8995_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7448_/X sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_110_clk clkbuf_4_2_0_clk/X VGND VGND VPWR VPWR _8953_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_122_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7379_ _8126_/Q _8094_/Q _8062_/Q _9054_/Q _7389_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7379_/X sky130_fd_sc_hd__mux4_2
XFILLER_1_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9049_ _9049_/CLK _9049_/D VGND VGND VPWR VPWR _9049_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_57_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_101_clk clkbuf_opt_0_clk/X VGND VGND VPWR VPWR _8790_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_114_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6750_ _6409_/Y _6278_/Y _6777_/S VGND VGND VPWR VPWR _9060_/D sky130_fd_sc_hd__mux2_1
XFILLER_90_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5701_ _5715_/A VGND VGND VPWR VPWR _5701_/X sky130_fd_sc_hd__buf_2
XFILLER_16_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6681_ _9055_/Q _4034_/A _4668_/A _4037_/A VGND VGND VPWR VPWR _9055_/D sky130_fd_sc_hd__a22o_1
X_8420_ _8708_/CLK _8420_/D VGND VGND VPWR VPWR _8420_/Q sky130_fd_sc_hd__dfxtp_1
X_5632_ _5646_/A VGND VGND VPWR VPWR _5632_/X sky130_fd_sc_hd__clkbuf_2
X_5563_ _5570_/A VGND VGND VPWR VPWR _5563_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_128_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8351_ _8735_/CLK _8351_/D VGND VGND VPWR VPWR _8351_/Q sky130_fd_sc_hd__dfxtp_1
X_4514_ _4528_/A VGND VGND VPWR VPWR _4514_/X sky130_fd_sc_hd__buf_2
X_7302_ _8823_/Q _8343_/Q _8951_/Q _8471_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7302_/X sky130_fd_sc_hd__mux4_1
X_8282_ _8922_/CLK _8282_/D VGND VGND VPWR VPWR _8282_/Q sky130_fd_sc_hd__dfxtp_1
X_5494_ _5501_/A VGND VGND VPWR VPWR _5494_/X sky130_fd_sc_hd__clkbuf_2
X_4445_ _4459_/A VGND VGND VPWR VPWR _4445_/X sky130_fd_sc_hd__buf_2
X_7233_ _8432_/Q _8304_/Q _8368_/Q _8560_/Q _7240_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7233_/X sky130_fd_sc_hd__mux4_1
X_7164_ _8521_/Q _8905_/Q _8841_/Q _8873_/Q _7185_/S0 _7185_/S1 VGND VGND VPWR VPWR
+ _7164_/X sky130_fd_sc_hd__mux4_1
X_4376_ _4376_/A VGND VGND VPWR VPWR _4376_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_98_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6115_ _6845_/X _6045_/A _6845_/X _6045_/A VGND VGND VPWR VPWR _6117_/A sky130_fd_sc_hd__o2bb2a_1
XFILLER_58_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7095_ _8706_/Q _8674_/Q _8642_/Q _8610_/Q _7135_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7095_/X sky130_fd_sc_hd__mux4_2
XFILLER_86_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6046_ _6997_/X _5890_/B _7000_/X _5882_/B VGND VGND VPWR VPWR _6046_/X sky130_fd_sc_hd__o22a_1
XFILLER_85_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7997_ _8607_/Q _8159_/Q _8511_/Q _8799_/Q _8000_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7997_/X sky130_fd_sc_hd__mux4_1
XFILLER_54_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6948_ _6947_/X _6949_/X _6948_/S VGND VGND VPWR VPWR _6948_/X sky130_fd_sc_hd__mux2_1
X_6879_ _6880_/X _6570_/B _6949_/S VGND VGND VPWR VPWR _6879_/X sky130_fd_sc_hd__mux2_2
XFILLER_50_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8618_ _8873_/CLK _8618_/D VGND VGND VPWR VPWR _8618_/Q sky130_fd_sc_hd__dfxtp_1
X_8549_ _8709_/CLK _8549_/D VGND VGND VPWR VPWR _8549_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4230_ _4230_/A VGND VGND VPWR VPWR _4230_/X sky130_fd_sc_hd__clkbuf_2
X_4161_ _4199_/A VGND VGND VPWR VPWR _4178_/A sky130_fd_sc_hd__buf_4
XFILLER_68_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4092_ _9028_/Q _4085_/X _4091_/X _4088_/X VGND VGND VPWR VPWR _9028_/D sky130_fd_sc_hd__a22o_1
XFILLER_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7920_ _8987_/Q _8411_/Q _8187_/Q _8763_/Q _8000_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7920_/X sky130_fd_sc_hd__mux4_2
XFILLER_48_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7851_ _7847_/X _7848_/X _7849_/X _7850_/X _5872_/A input11/X VGND VGND VPWR VPWR
+ _7851_/X sky130_fd_sc_hd__mux4_2
XFILLER_36_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6802_ _6599_/Y _6597_/X _6809_/S VGND VGND VPWR VPWR _6802_/X sky130_fd_sc_hd__mux2_2
XFILLER_36_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4994_ _8510_/Q _4989_/X _4866_/X _4992_/X VGND VGND VPWR VPWR _8510_/D sky130_fd_sc_hd__a22o_1
X_7782_ _8820_/Q _8340_/Q _8948_/Q _8468_/Q _7949_/S0 input9/X VGND VGND VPWR VPWR
+ _7782_/X sky130_fd_sc_hd__mux4_1
XFILLER_17_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6733_ _6732_/X _9081_/Q _6733_/S VGND VGND VPWR VPWR _6733_/X sky130_fd_sc_hd__mux2_1
XFILLER_32_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6664_ _6666_/A _6664_/B VGND VGND VPWR VPWR _6664_/Y sky130_fd_sc_hd__nor2_1
XFILLER_137_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5615_ _8137_/Q _5611_/X _5460_/X _5612_/X VGND VGND VPWR VPWR _8137_/D sky130_fd_sc_hd__a22o_1
X_8403_ _8403_/CLK _8403_/D VGND VGND VPWR VPWR _8403_/Q sky130_fd_sc_hd__dfxtp_1
X_6595_ _6462_/A _6462_/B _6463_/B VGND VGND VPWR VPWR _6595_/X sky130_fd_sc_hd__a21bo_1
X_8334_ _8941_/CLK _8334_/D VGND VGND VPWR VPWR _8334_/Q sky130_fd_sc_hd__dfxtp_1
X_5546_ _8184_/Q _5542_/X _5424_/X _5543_/X VGND VGND VPWR VPWR _8184_/D sky130_fd_sc_hd__a22o_1
X_8265_ _8586_/CLK _8265_/D VGND VGND VPWR VPWR _8265_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5477_ _8226_/Q _5466_/X _5476_/X _5468_/X VGND VGND VPWR VPWR _8226_/D sky130_fd_sc_hd__a22o_1
XFILLER_105_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4428_ _8840_/Q _4423_/X _4370_/X _4424_/X VGND VGND VPWR VPWR _8840_/D sky130_fd_sc_hd__a22o_1
X_7216_ _7212_/X _7213_/X _7214_/X _7215_/X _7241_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7216_/X sky130_fd_sc_hd__mux4_1
XFILLER_132_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8196_ _9004_/CLK _8196_/D VGND VGND VPWR VPWR _8196_/Q sky130_fd_sc_hd__dfxtp_1
X_7147_ _8583_/Q _8135_/Q _8487_/Q _8775_/Q _7184_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7147_/X sky130_fd_sc_hd__mux4_1
X_4359_ _8877_/Q _4350_/X _4358_/X _4352_/X VGND VGND VPWR VPWR _8877_/D sky130_fd_sc_hd__a22o_1
XFILLER_86_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7078_ _8256_/Q _8224_/Q _8192_/Q _8992_/Q _7369_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7078_/X sky130_fd_sc_hd__mux4_1
XFILLER_48_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6029_ _7017_/X _6032_/B VGND VGND VPWR VPWR _6030_/A sky130_fd_sc_hd__nand2_2
XFILLER_104_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5400_ _8258_/Q _5394_/X _5204_/X _5395_/X VGND VGND VPWR VPWR _8258_/D sky130_fd_sc_hd__a22o_1
X_6380_ _6388_/A _6385_/A _6379_/Y _6311_/C VGND VGND VPWR VPWR _6380_/X sky130_fd_sc_hd__o31a_1
XFILLER_127_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5331_ _8305_/Q _5325_/X _5168_/X _5326_/X VGND VGND VPWR VPWR _8305_/D sky130_fd_sc_hd__a22o_1
X_8050_ _9044_/CLK _8050_/D VGND VGND VPWR VPWR _8050_/Q sky130_fd_sc_hd__dfxtp_1
X_7001_ _7566_/X _7571_/X _7067_/S VGND VGND VPWR VPWR _7001_/X sky130_fd_sc_hd__mux2_2
XFILLER_114_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5262_ _5298_/A VGND VGND VPWR VPWR _5299_/A sky130_fd_sc_hd__clkinv_4
X_5193_ _8391_/Q _5182_/X _5192_/X _5184_/X VGND VGND VPWR VPWR _8391_/D sky130_fd_sc_hd__a22o_1
X_4213_ _4251_/A VGND VGND VPWR VPWR _4230_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_87_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4144_ _9002_/Q _4141_/X _4070_/X _4142_/X VGND VGND VPWR VPWR _9002_/D sky130_fd_sc_hd__a22o_1
XFILLER_110_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4075_ _9033_/Q _4068_/X _4074_/X _4071_/X VGND VGND VPWR VPWR _9033_/D sky130_fd_sc_hd__a22o_1
XFILLER_110_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8952_ _8952_/CLK _8952_/D VGND VGND VPWR VPWR _8952_/Q sky130_fd_sc_hd__dfxtp_1
X_8883_ _8947_/CLK _8883_/D VGND VGND VPWR VPWR _8883_/Q sky130_fd_sc_hd__dfxtp_1
X_7903_ _8442_/Q _8314_/Q _8378_/Q _8570_/Q _7907_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7903_/X sky130_fd_sc_hd__mux4_1
XFILLER_36_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_90_clk clkbuf_4_8_0_clk/X VGND VGND VPWR VPWR _9082_/CLK sky130_fd_sc_hd__clkbuf_16
X_7834_ _8535_/Q _8919_/Q _8855_/Q _8887_/Q _7894_/S0 _7897_/S1 VGND VGND VPWR VPWR
+ _7834_/X sky130_fd_sc_hd__mux4_1
XPHY_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7765_ _8723_/Q _8691_/Q _8659_/Q _8627_/Q _7949_/S0 input9/X VGND VGND VPWR VPWR
+ _7765_/X sky130_fd_sc_hd__mux4_2
XFILLER_63_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4977_ _8519_/Q _4971_/X _4920_/X _4972_/X VGND VGND VPWR VPWR _8519_/D sky130_fd_sc_hd__a22o_1
XPHY_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6716_ _7246_/X _7251_/X _6734_/S VGND VGND VPWR VPWR _6716_/X sky130_fd_sc_hd__mux2_1
X_7696_ _7692_/X _7693_/X _7694_/X _7695_/X _7701_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7696_/X sky130_fd_sc_hd__mux4_2
X_6647_ _6647_/A VGND VGND VPWR VPWR _6647_/Y sky130_fd_sc_hd__inv_2
XFILLER_137_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6578_ _6410_/X _7031_/X VGND VGND VPWR VPWR _6578_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_133_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8317_ _8863_/CLK _8317_/D VGND VGND VPWR VPWR _8317_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_106_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5529_ _8193_/Q _5501_/A _5478_/X _5502_/A VGND VGND VPWR VPWR _8193_/D sky130_fd_sc_hd__a22o_1
XFILLER_117_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8248_ _8986_/CLK _8248_/D VGND VGND VPWR VPWR _8248_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_120_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8179_ _8403_/CLK _8179_/D VGND VGND VPWR VPWR _8179_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_115_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_81_clk clkbuf_4_11_0_clk/X VGND VGND VPWR VPWR _8941_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_70_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4900_ _4924_/A VGND VGND VPWR VPWR _4900_/X sky130_fd_sc_hd__buf_2
X_5880_ _6433_/A _6919_/X VGND VGND VPWR VPWR _5881_/A sky130_fd_sc_hd__or2_1
XFILLER_46_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_72_clk clkbuf_opt_0_clk/A VGND VGND VPWR VPWR _8236_/CLK sky130_fd_sc_hd__clkbuf_16
X_4831_ _8596_/Q _4828_/X _4617_/X _4829_/X VGND VGND VPWR VPWR _8596_/D sky130_fd_sc_hd__a22o_1
XFILLER_33_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_1_0_clk clkbuf_2_1_0_clk/A VGND VGND VPWR VPWR clkbuf_3_3_0_clk/A sky130_fd_sc_hd__clkbuf_1
XFILLER_61_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7550_ _8968_/Q _8392_/Q _8168_/Q _8744_/Q _7550_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7550_/X sky130_fd_sc_hd__mux4_1
X_4762_ _5035_/A _4762_/B VGND VGND VPWR VPWR _4801_/A sky130_fd_sc_hd__or2_4
X_7481_ _7477_/X _7478_/X _7479_/X _7480_/X _7501_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7481_/X sky130_fd_sc_hd__mux4_1
X_6501_ _6536_/A _6501_/B _6501_/C _6501_/D VGND VGND VPWR VPWR _6502_/A sky130_fd_sc_hd__or4_4
X_4693_ _8688_/Q _4691_/X _4626_/X _4692_/X VGND VGND VPWR VPWR _8688_/D sky130_fd_sc_hd__a22o_1
X_6432_ _6410_/X _7037_/X VGND VGND VPWR VPWR _6432_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_134_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8102_ _9028_/CLK _8102_/D VGND VGND VPWR VPWR _8102_/Q sky130_fd_sc_hd__dfxtp_1
X_6363_ _6105_/X _7058_/X VGND VGND VPWR VPWR _6363_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_114_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5314_ _8318_/Q _5309_/X _5138_/X _5312_/X VGND VGND VPWR VPWR _8318_/D sky130_fd_sc_hd__a22o_1
X_6294_ _3989_/A _6287_/Y _6289_/Y _6293_/X VGND VGND VPWR VPWR _6295_/A sky130_fd_sc_hd__o22a_1
X_9082_ _9082_/CLK _9082_/D repeater147/X VGND VGND VPWR VPWR _9082_/Q sky130_fd_sc_hd__dfrtp_4
X_5245_ _8363_/Q _5243_/X _5183_/X _5244_/X VGND VGND VPWR VPWR _8363_/D sky130_fd_sc_hd__a22o_1
XFILLER_114_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8033_ _9057_/CLK _8033_/D VGND VGND VPWR VPWR _8033_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_130_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5176_ _6792_/X VGND VGND VPWR VPWR _5176_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_28_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4127_ _4127_/A VGND VGND VPWR VPWR _4127_/X sky130_fd_sc_hd__buf_2
X_8935_ _8939_/CLK _8935_/D VGND VGND VPWR VPWR _8935_/Q sky130_fd_sc_hd__dfxtp_1
X_4058_ _9038_/Q _4051_/X _4057_/X _4054_/X VGND VGND VPWR VPWR _9038_/D sky130_fd_sc_hd__a22o_1
XFILLER_25_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8866_ _8933_/CLK _8866_/D VGND VGND VPWR VPWR _8866_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_63_clk clkbuf_4_14_0_clk/X VGND VGND VPWR VPWR _9029_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_52_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8797_ _8958_/CLK _8797_/D VGND VGND VPWR VPWR _8797_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7817_ _8598_/Q _8150_/Q _8502_/Q _8790_/Q input14/X _7900_/S1 VGND VGND VPWR VPWR
+ _7817_/X sky130_fd_sc_hd__mux4_2
XFILLER_61_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7748_ _8274_/Q _8242_/Q _8210_/Q _9010_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7748_/X sky130_fd_sc_hd__mux4_2
X_7679_ _8111_/Q _8079_/Q _8047_/Q _9039_/Q _7700_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7679_/X sky130_fd_sc_hd__mux4_1
XFILLER_4_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_54_clk clkbuf_4_13_0_clk/X VGND VGND VPWR VPWR _8932_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_15_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5030_ _8484_/Q _5026_/X _4928_/X _5027_/X VGND VGND VPWR VPWR _8484_/D sky130_fd_sc_hd__a22o_1
XFILLER_66_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6981_ _7436_/X _7441_/X _7020_/S VGND VGND VPWR VPWR _6981_/X sky130_fd_sc_hd__mux2_2
XFILLER_66_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5932_ _5927_/A _5860_/B _5861_/B VGND VGND VPWR VPWR _5932_/X sky130_fd_sc_hd__a21o_1
XFILLER_65_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8720_ _8942_/CLK _8720_/D VGND VGND VPWR VPWR _8720_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_25_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_45_clk _9063_/CLK VGND VGND VPWR VPWR _9035_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_34_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8651_ _8873_/CLK _8651_/D VGND VGND VPWR VPWR _8651_/Q sky130_fd_sc_hd__dfxtp_1
X_5863_ _5908_/A _5863_/B VGND VGND VPWR VPWR _5864_/B sky130_fd_sc_hd__or2_1
X_7602_ _8811_/Q _8331_/Q _8939_/Q _8459_/Q _7604_/S0 _7604_/S1 VGND VGND VPWR VPWR
+ _7602_/X sky130_fd_sc_hd__mux4_1
X_8582_ _8966_/CLK _8582_/D VGND VGND VPWR VPWR _8582_/Q sky130_fd_sc_hd__dfxtp_1
X_4814_ _4850_/A VGND VGND VPWR VPWR _4829_/A sky130_fd_sc_hd__buf_4
X_5794_ _6861_/X _5900_/B _5788_/Y _5793_/A VGND VGND VPWR VPWR _5797_/A sky130_fd_sc_hd__a22o_1
X_7533_ _8424_/Q _8296_/Q _8360_/Q _8552_/Q _7975_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7533_/X sky130_fd_sc_hd__mux4_2
X_4745_ _8652_/Q _4739_/X _4635_/X _4740_/X VGND VGND VPWR VPWR _8652_/D sky130_fd_sc_hd__a22o_1
X_7464_ _8516_/Q _8900_/Q _8836_/Q _8868_/Q _7610_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7464_/X sky130_fd_sc_hd__mux4_2
X_4676_ _8699_/Q _4667_/X _4599_/X _4671_/X VGND VGND VPWR VPWR _8699_/D sky130_fd_sc_hd__a22o_1
XFILLER_107_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6415_ _6415_/A _6415_/B VGND VGND VPWR VPWR _6416_/A sky130_fd_sc_hd__nor2_1
X_7395_ _8705_/Q _8673_/Q _8641_/Q _8609_/Q _7594_/S0 _5772_/B VGND VGND VPWR VPWR
+ _7395_/X sky130_fd_sc_hd__mux4_1
XFILLER_115_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6346_ _6186_/Y _6345_/X _6186_/Y _6345_/X VGND VGND VPWR VPWR _6346_/Y sky130_fd_sc_hd__a2bb2oi_1
X_9065_ _9067_/CLK _9065_/D repeater146/X VGND VGND VPWR VPWR _9065_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_0_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6277_ _9060_/Q _6282_/A _6264_/B VGND VGND VPWR VPWR _6278_/A sky130_fd_sc_hd__o21ai_2
X_8016_ _8012_/X _8013_/X _8014_/X _8015_/X _6098_/A _5873_/B VGND VGND VPWR VPWR
+ _8016_/X sky130_fd_sc_hd__mux4_1
XFILLER_102_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5228_ _8374_/Q _5222_/X _5156_/X _5223_/X VGND VGND VPWR VPWR _8374_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5159_ _6799_/X VGND VGND VPWR VPWR _5159_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_72_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_36_clk clkbuf_4_7_0_clk/X VGND VGND VPWR VPWR _8939_/CLK sky130_fd_sc_hd__clkbuf_16
X_8918_ _8950_/CLK _8918_/D VGND VGND VPWR VPWR _8918_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_112_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8849_ _9024_/CLK _8849_/D VGND VGND VPWR VPWR _8849_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_27_clk clkbuf_4_5_0_clk/X VGND VGND VPWR VPWR _8731_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_16_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4530_ _8774_/Q _4528_/X _4375_/X _4529_/X VGND VGND VPWR VPWR _8774_/D sky130_fd_sc_hd__a22o_1
XPHY_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4461_ _8820_/Q _4458_/X _4342_/X _4459_/X VGND VGND VPWR VPWR _8820_/D sky130_fd_sc_hd__a22o_1
XFILLER_132_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7180_ _8970_/Q _8394_/Q _8170_/Q _8746_/Q _7190_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7180_/X sky130_fd_sc_hd__mux4_1
X_6200_ _6177_/A _6198_/Y _6199_/X VGND VGND VPWR VPWR _6205_/C sky130_fd_sc_hd__o21ai_2
XFILLER_131_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4392_ _4409_/A VGND VGND VPWR VPWR _4392_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_98_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6131_ _9064_/Q VGND VGND VPWR VPWR _6255_/A sky130_fd_sc_hd__inv_2
XFILLER_124_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6062_ _7071_/X _5985_/B _7069_/X _6976_/X _5947_/B VGND VGND VPWR VPWR _6062_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_100_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5013_ _5027_/A VGND VGND VPWR VPWR _5013_/X sky130_fd_sc_hd__clkbuf_2
Xrepeater112 _7665_/S1 VGND VGND VPWR VPWR _6099_/A sky130_fd_sc_hd__buf_8
Xrepeater123 input9/X VGND VGND VPWR VPWR _7808_/S1 sky130_fd_sc_hd__buf_8
Xrepeater134 _7909_/S0 VGND VGND VPWR VPWR _7910_/S0 sky130_fd_sc_hd__buf_8
Xrepeater145 input8/X VGND VGND VPWR VPWR _7604_/S0 sky130_fd_sc_hd__buf_8
Xrepeater156 input35/X VGND VGND VPWR VPWR _7241_/S0 sky130_fd_sc_hd__buf_8
Xrepeater167 _7349_/S1 VGND VGND VPWR VPWR _7380_/S1 sky130_fd_sc_hd__buf_8
Xrepeater189 _6343_/A VGND VGND VPWR VPWR _7390_/S0 sky130_fd_sc_hd__buf_8
XFILLER_54_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater178 input34/X VGND VGND VPWR VPWR _7240_/S1 sky130_fd_sc_hd__clkbuf_8
XFILLER_39_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_18_clk clkbuf_4_4_0_clk/X VGND VGND VPWR VPWR _8989_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_81_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6964_ _6968_/X _6965_/X _6964_/S VGND VGND VPWR VPWR _6964_/X sky130_fd_sc_hd__mux2_1
XFILLER_54_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8703_ _8735_/CLK _8703_/D VGND VGND VPWR VPWR _8703_/Q sky130_fd_sc_hd__dfxtp_1
X_5915_ _6871_/X _5907_/X _5913_/X _5914_/Y VGND VGND VPWR VPWR _5915_/Y sky130_fd_sc_hd__o22ai_1
X_6895_ _6937_/X _6935_/X _6939_/S VGND VGND VPWR VPWR _6895_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5846_ _6110_/C VGND VGND VPWR VPWR _5846_/X sky130_fd_sc_hd__clkbuf_2
X_8634_ _8729_/CLK _8634_/D VGND VGND VPWR VPWR _8634_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5777_ _6848_/X _5848_/A _6848_/X _5848_/A VGND VGND VPWR VPWR _5778_/A sky130_fd_sc_hd__o2bb2a_1
X_8565_ _8821_/CLK _8565_/D VGND VGND VPWR VPWR _8565_/Q sky130_fd_sc_hd__dfxtp_1
X_7516_ _7512_/X _7513_/X _7514_/X _7515_/X _5771_/C _5771_/B VGND VGND VPWR VPWR
+ _7516_/X sky130_fd_sc_hd__mux4_2
X_8496_ _8816_/CLK _8496_/D VGND VGND VPWR VPWR _8496_/Q sky130_fd_sc_hd__dfxtp_1
X_4728_ _8665_/Q _4725_/X _4605_/X _4726_/X VGND VGND VPWR VPWR _8665_/D sky130_fd_sc_hd__a22o_1
X_7447_ _8579_/Q _8131_/Q _8483_/Q _8771_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7447_/X sky130_fd_sc_hd__mux4_1
X_4659_ _4659_/A VGND VGND VPWR VPWR _4659_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_101_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7378_ _8286_/Q _8254_/Q _8222_/Q _9022_/Q _7389_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7378_/X sky130_fd_sc_hd__mux4_1
XFILLER_1_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6329_ _6329_/A _6329_/B VGND VGND VPWR VPWR _6335_/A sky130_fd_sc_hd__or2_1
XFILLER_88_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9048_ _9048_/CLK _9048_/D VGND VGND VPWR VPWR _9048_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_67_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5700_ _5714_/A VGND VGND VPWR VPWR _5700_/X sky130_fd_sc_hd__buf_2
XFILLER_92_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6680_ _6105_/A _7007_/X VGND VGND VPWR VPWR _6680_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_31_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5631_ _5667_/A VGND VGND VPWR VPWR _5646_/A sky130_fd_sc_hd__buf_4
XFILLER_129_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8350_ _8863_/CLK _8350_/D VGND VGND VPWR VPWR _8350_/Q sky130_fd_sc_hd__dfxtp_1
X_5562_ _8172_/Q _5556_/X _5452_/X _5557_/X VGND VGND VPWR VPWR _8172_/D sky130_fd_sc_hd__a22o_1
XFILLER_129_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8281_ _8951_/CLK _8281_/D VGND VGND VPWR VPWR _8281_/Q sky130_fd_sc_hd__dfxtp_1
X_4513_ _8785_/Q _4507_/X _4348_/X _4508_/X VGND VGND VPWR VPWR _8785_/D sky130_fd_sc_hd__a22o_1
X_7301_ _7297_/X _7298_/X _7299_/X _7300_/X _7341_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7301_/X sky130_fd_sc_hd__mux4_1
XFILLER_105_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5493_ _8219_/Q _5484_/X _5416_/X _5488_/X VGND VGND VPWR VPWR _8219_/D sky130_fd_sc_hd__a22o_1
X_7232_ _8816_/Q _8336_/Q _8944_/Q _8464_/Q _7240_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7232_/X sky130_fd_sc_hd__mux4_1
XFILLER_132_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4444_ _4480_/A VGND VGND VPWR VPWR _4459_/A sky130_fd_sc_hd__clkbuf_4
Xclkbuf_leaf_7_clk clkbuf_4_1_0_clk/X VGND VGND VPWR VPWR _9051_/CLK sky130_fd_sc_hd__clkbuf_16
X_7163_ _8425_/Q _8297_/Q _8361_/Q _8553_/Q _7185_/S0 _7185_/S1 VGND VGND VPWR VPWR
+ _7163_/X sky130_fd_sc_hd__mux4_2
X_4375_ _4650_/A VGND VGND VPWR VPWR _4375_/X sky130_fd_sc_hd__clkbuf_2
X_7094_ _8514_/Q _8898_/Q _8834_/Q _8866_/Q _7130_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7094_/X sky130_fd_sc_hd__mux4_1
X_6114_ _6185_/A VGND VGND VPWR VPWR _6114_/X sky130_fd_sc_hd__buf_8
XFILLER_100_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6045_ _6045_/A VGND VGND VPWR VPWR _6101_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_39_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7996_ _7992_/X _7993_/X _7994_/X _7995_/X _7996_/S0 _5771_/B VGND VGND VPWR VPWR
+ _7996_/X sky130_fd_sc_hd__mux4_2
XFILLER_81_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6947_ _6946_/X _6964_/X _6949_/S VGND VGND VPWR VPWR _6947_/X sky130_fd_sc_hd__mux2_1
XFILLER_41_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6878_ _6877_/X _6879_/X _6948_/S VGND VGND VPWR VPWR _6878_/X sky130_fd_sc_hd__mux2_1
X_8617_ _8873_/CLK _8617_/D VGND VGND VPWR VPWR _8617_/Q sky130_fd_sc_hd__dfxtp_1
X_5829_ _6912_/X _5944_/B _6897_/X _5813_/A VGND VGND VPWR VPWR _5829_/X sky130_fd_sc_hd__a22o_1
XFILLER_10_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8548_ _8708_/CLK _8548_/D VGND VGND VPWR VPWR _8548_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8479_ _8735_/CLK _8479_/D VGND VGND VPWR VPWR _8479_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_5_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4160_ _5531_/A _5627_/B VGND VGND VPWR VPWR _4199_/A sky130_fd_sc_hd__or2_4
XFILLER_4_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4091_ _4655_/A VGND VGND VPWR VPWR _4091_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_67_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7850_ _8983_/Q _8407_/Q _8183_/Q _8759_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7850_/X sky130_fd_sc_hd__mux4_1
XFILLER_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6801_ _6608_/Y _6618_/Y _6809_/S VGND VGND VPWR VPWR _6801_/X sky130_fd_sc_hd__mux2_2
X_4993_ _8511_/Q _4989_/X _4941_/X _4992_/X VGND VGND VPWR VPWR _8511_/D sky130_fd_sc_hd__a22o_1
X_7781_ _7777_/X _7778_/X _7779_/X _7780_/X _7801_/S0 input17/X VGND VGND VPWR VPWR
+ _7781_/X sky130_fd_sc_hd__mux4_2
X_6732_ _7326_/X _7331_/X _6734_/S VGND VGND VPWR VPWR _6732_/X sky130_fd_sc_hd__mux2_1
X_6663_ _6524_/A _6662_/X _6524_/A _6662_/X VGND VGND VPWR VPWR _6663_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_137_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5614_ _8138_/Q _5611_/X _5458_/X _5612_/X VGND VGND VPWR VPWR _8138_/D sky130_fd_sc_hd__a22o_1
X_8402_ _8787_/CLK _8402_/D VGND VGND VPWR VPWR _8402_/Q sky130_fd_sc_hd__dfxtp_1
X_6594_ _5881_/X _6584_/X _7000_/X _6572_/X _6593_/Y VGND VGND VPWR VPWR _6594_/Y
+ sky130_fd_sc_hd__o221ai_1
XFILLER_117_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8333_ _8781_/CLK _8333_/D VGND VGND VPWR VPWR _8333_/Q sky130_fd_sc_hd__dfxtp_1
X_5545_ _8185_/Q _5542_/X _5422_/X _5543_/X VGND VGND VPWR VPWR _8185_/D sky130_fd_sc_hd__a22o_1
X_8264_ _9000_/CLK _8264_/D VGND VGND VPWR VPWR _8264_/Q sky130_fd_sc_hd__dfxtp_1
X_5476_ _6780_/X VGND VGND VPWR VPWR _5476_/X sky130_fd_sc_hd__clkbuf_2
X_4427_ _8841_/Q _4423_/X _4368_/X _4424_/X VGND VGND VPWR VPWR _8841_/D sky130_fd_sc_hd__a22o_1
X_8195_ _9062_/CLK _8195_/D VGND VGND VPWR VPWR _8195_/Q sky130_fd_sc_hd__dfxtp_1
X_7215_ _8718_/Q _8686_/Q _8654_/Q _8622_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7215_/X sky130_fd_sc_hd__mux4_1
X_7146_ _7142_/X _7143_/X _7144_/X _7145_/X _7391_/S0 _7381_/S1 VGND VGND VPWR VPWR
+ _7146_/X sky130_fd_sc_hd__mux4_1
XFILLER_113_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4358_ _4633_/A VGND VGND VPWR VPWR _4358_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_100_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4289_ _4303_/A VGND VGND VPWR VPWR _4289_/X sky130_fd_sc_hd__buf_2
X_7077_ _8576_/Q _8128_/Q _8480_/Q _8768_/Q _7369_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7077_/X sky130_fd_sc_hd__mux4_1
XFILLER_101_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6028_ _6028_/A _6028_/B _6027_/X VGND VGND VPWR VPWR _6085_/C sky130_fd_sc_hd__or3b_4
XFILLER_27_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7979_ _8126_/Q _8094_/Q _8062_/Q _9054_/Q _8025_/S0 _5772_/B VGND VGND VPWR VPWR
+ _7979_/X sky130_fd_sc_hd__mux4_1
XFILLER_120_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5330_ _8306_/Q _5325_/X _5166_/X _5326_/X VGND VGND VPWR VPWR _8306_/D sky130_fd_sc_hd__a22o_1
XFILLER_114_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5261_ _5277_/A VGND VGND VPWR VPWR _5261_/X sky130_fd_sc_hd__buf_2
XFILLER_114_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4212_ _5259_/A _5210_/A VGND VGND VPWR VPWR _4251_/A sky130_fd_sc_hd__or2_4
X_7000_ _5892_/Y _6257_/A _7069_/S VGND VGND VPWR VPWR _7000_/X sky130_fd_sc_hd__mux2_4
X_5192_ _6785_/X VGND VGND VPWR VPWR _5192_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_110_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4143_ _9003_/Q _4141_/X _4066_/X _4142_/X VGND VGND VPWR VPWR _9003_/D sky130_fd_sc_hd__a22o_1
XFILLER_96_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4074_ _4643_/A VGND VGND VPWR VPWR _4074_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_55_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8951_ _8951_/CLK _8951_/D VGND VGND VPWR VPWR _8951_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_28_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7902_ _8826_/Q _8346_/Q _8954_/Q _8474_/Q _7907_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7902_/X sky130_fd_sc_hd__mux4_1
XFILLER_70_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8882_ _8882_/CLK _8882_/D VGND VGND VPWR VPWR _8882_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_24_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7833_ _8439_/Q _8311_/Q _8375_/Q _8567_/Q _7894_/S0 _7897_/S1 VGND VGND VPWR VPWR
+ _7833_/X sky130_fd_sc_hd__mux4_1
XPHY_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7764_ _8531_/Q _8915_/Q _8851_/Q _8883_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7764_/X sky130_fd_sc_hd__mux4_1
X_4976_ _8520_/Q _4971_/X _4918_/X _4972_/X VGND VGND VPWR VPWR _8520_/D sky130_fd_sc_hd__a22o_1
XPHY_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6715_ _6714_/X _9072_/Q _6735_/S VGND VGND VPWR VPWR _6715_/X sky130_fd_sc_hd__mux2_1
X_7695_ _8720_/Q _8688_/Q _8656_/Q _8624_/Q _7697_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7695_/X sky130_fd_sc_hd__mux4_2
XFILLER_109_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6646_ _6498_/Y _6010_/A _6614_/Y _6501_/D VGND VGND VPWR VPWR _6647_/A sky130_fd_sc_hd__o22a_1
XFILLER_118_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6577_ _6472_/X _6576_/X _6472_/X _6576_/X VGND VGND VPWR VPWR _6577_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_117_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8316_ _8731_/CLK _8316_/D VGND VGND VPWR VPWR _8316_/Q sky130_fd_sc_hd__dfxtp_1
X_5528_ _8194_/Q _5522_/X _5476_/X _5523_/X VGND VGND VPWR VPWR _8194_/D sky130_fd_sc_hd__a22o_1
XFILLER_133_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5459_ _8234_/Q _5454_/X _5458_/X _5456_/X VGND VGND VPWR VPWR _8234_/D sky130_fd_sc_hd__a22o_1
XFILLER_105_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8247_ _9049_/CLK _8247_/D VGND VGND VPWR VPWR _8247_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_59_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8178_ _9044_/CLK _8178_/D VGND VGND VPWR VPWR _8178_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_113_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7129_ _8101_/Q _8069_/Q _8037_/Q _9029_/Q _7130_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7129_/X sky130_fd_sc_hd__mux4_1
XFILLER_87_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4830_ _8597_/Q _4828_/X _4614_/X _4829_/X VGND VGND VPWR VPWR _8597_/D sky130_fd_sc_hd__a22o_1
X_4761_ _8640_/Q _4732_/A _4663_/X _4733_/A VGND VGND VPWR VPWR _8640_/D sky130_fd_sc_hd__a22o_1
XFILLER_60_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7480_ _8965_/Q _8389_/Q _8165_/Q _8741_/Q _7480_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7480_/X sky130_fd_sc_hd__mux4_1
X_4692_ _4706_/A VGND VGND VPWR VPWR _4692_/X sky130_fd_sc_hd__clkbuf_2
X_6500_ _6500_/A VGND VGND VPWR VPWR _6501_/D sky130_fd_sc_hd__inv_2
X_6431_ _6291_/A _6291_/B _6291_/Y VGND VGND VPWR VPWR _6431_/Y sky130_fd_sc_hd__a21oi_1
X_6362_ _6222_/C _6361_/X _6222_/C _6361_/X VGND VGND VPWR VPWR _6362_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_127_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5313_ _8319_/Q _5309_/X _5213_/X _5312_/X VGND VGND VPWR VPWR _8319_/D sky130_fd_sc_hd__a22o_1
X_8101_ _8994_/CLK _8101_/D VGND VGND VPWR VPWR _8101_/Q sky130_fd_sc_hd__dfxtp_1
X_6293_ _3986_/A _6290_/X _6291_/Y _6292_/X VGND VGND VPWR VPWR _6293_/X sky130_fd_sc_hd__a22o_1
X_9081_ _9082_/CLK _9081_/D repeater147/X VGND VGND VPWR VPWR _9081_/Q sky130_fd_sc_hd__dfrtp_2
X_5244_ _5251_/A VGND VGND VPWR VPWR _5244_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_102_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8032_ _8032_/CLK _8032_/D VGND VGND VPWR VPWR _8032_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_102_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5175_ _8399_/Q _5170_/X _5174_/X _5172_/X VGND VGND VPWR VPWR _8399_/D sky130_fd_sc_hd__a22o_1
XFILLER_29_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4126_ _9014_/Q _4120_/X _4029_/X _4121_/X VGND VGND VPWR VPWR _9014_/D sky130_fd_sc_hd__a22o_1
X_8934_ _8934_/CLK _8934_/D VGND VGND VPWR VPWR _8934_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_83_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4057_ _4631_/A VGND VGND VPWR VPWR _4057_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_37_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8865_ _8929_/CLK _8865_/D VGND VGND VPWR VPWR _8865_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_25_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7816_ _7812_/X _7813_/X _7814_/X _7815_/X _7901_/S0 _8031_/S1 VGND VGND VPWR VPWR
+ _7816_/X sky130_fd_sc_hd__mux4_1
XFILLER_101_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8796_ _8991_/CLK _8796_/D VGND VGND VPWR VPWR _8796_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_52_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4959_ _8533_/Q _4957_/X _4887_/X _4958_/X VGND VGND VPWR VPWR _8533_/D sky130_fd_sc_hd__a22o_1
X_7747_ _8594_/Q _8146_/Q _8498_/Q _8786_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7747_/X sky130_fd_sc_hd__mux4_1
XFILLER_138_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7678_ _8271_/Q _8239_/Q _8207_/Q _9007_/Q _7700_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7678_/X sky130_fd_sc_hd__mux4_1
X_6629_ _6458_/A _6458_/B _6612_/B VGND VGND VPWR VPWR _6629_/X sky130_fd_sc_hd__a21bo_1
XFILLER_118_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6980_ _7426_/X _7431_/X _7022_/S VGND VGND VPWR VPWR _6980_/X sky130_fd_sc_hd__mux2_2
X_5931_ _6974_/S VGND VGND VPWR VPWR _5931_/Y sky130_fd_sc_hd__inv_2
XFILLER_80_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8650_ _8938_/CLK _8650_/D VGND VGND VPWR VPWR _8650_/Q sky130_fd_sc_hd__dfxtp_1
X_5862_ _5914_/A _5862_/B VGND VGND VPWR VPWR _5863_/B sky130_fd_sc_hd__or2_1
XFILLER_80_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7601_ _7597_/X _7598_/X _7599_/X _7600_/X _5771_/C _7601_/S1 VGND VGND VPWR VPWR
+ _7601_/X sky130_fd_sc_hd__mux4_1
X_8581_ _8934_/CLK _8581_/D VGND VGND VPWR VPWR _8581_/Q sky130_fd_sc_hd__dfxtp_1
X_4813_ _4849_/A VGND VGND VPWR VPWR _4850_/A sky130_fd_sc_hd__inv_2
X_5793_ _5793_/A VGND VGND VPWR VPWR _5900_/B sky130_fd_sc_hd__inv_2
X_7532_ _8808_/Q _8328_/Q _8936_/Q _8456_/Q _7975_/S0 _5772_/B VGND VGND VPWR VPWR
+ _7532_/X sky130_fd_sc_hd__mux4_1
X_4744_ _8653_/Q _4739_/X _4633_/X _4740_/X VGND VGND VPWR VPWR _8653_/D sky130_fd_sc_hd__a22o_1
XFILLER_119_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7463_ _8420_/Q _8292_/Q _8356_/Q _8548_/Q _7610_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7463_/X sky130_fd_sc_hd__mux4_1
X_4675_ _8700_/Q _4667_/X _4597_/X _4671_/X VGND VGND VPWR VPWR _8700_/D sky130_fd_sc_hd__a22o_1
X_6414_ _6293_/X _6413_/X _6293_/X _6413_/X VGND VGND VPWR VPWR _6414_/Y sky130_fd_sc_hd__a2bb2oi_1
X_7394_ _8513_/Q _8897_/Q _8833_/Q _8865_/Q _5771_/A _5772_/B VGND VGND VPWR VPWR
+ _7394_/X sky130_fd_sc_hd__mux4_1
XFILLER_134_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6345_ _6336_/X _6182_/Y _6181_/X VGND VGND VPWR VPWR _6345_/X sky130_fd_sc_hd__o21a_1
X_6276_ _6276_/A VGND VGND VPWR VPWR _6282_/A sky130_fd_sc_hd__inv_2
X_9064_ _9064_/CLK _9064_/D repeater146/X VGND VGND VPWR VPWR _9064_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_130_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8015_ _8704_/Q _8672_/Q _8640_/Q _8608_/Q _8015_/S0 _5872_/B VGND VGND VPWR VPWR
+ _8015_/X sky130_fd_sc_hd__mux4_1
X_5227_ _8375_/Q _5222_/X _5154_/X _5223_/X VGND VGND VPWR VPWR _8375_/D sky130_fd_sc_hd__a22o_1
XFILLER_0_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5158_ _5158_/A VGND VGND VPWR VPWR _5158_/X sky130_fd_sc_hd__buf_2
XFILLER_110_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5089_ _8447_/Q _5085_/X _4941_/X _5088_/X VGND VGND VPWR VPWR _8447_/D sky130_fd_sc_hd__a22o_1
X_4109_ _4127_/A VGND VGND VPWR VPWR _4109_/X sky130_fd_sc_hd__buf_2
XFILLER_56_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8917_ _8945_/CLK _8917_/D VGND VGND VPWR VPWR _8917_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8848_ _8944_/CLK _8848_/D VGND VGND VPWR VPWR _8848_/Q sky130_fd_sc_hd__dfxtp_1
X_8779_ _8999_/CLK _8779_/D VGND VGND VPWR VPWR _8779_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_2_0_0_clk clkbuf_2_1_0_clk/A VGND VGND VPWR VPWR clkbuf_3_1_0_clk/A sky130_fd_sc_hd__clkbuf_1
XFILLER_75_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4460_ _8821_/Q _4458_/X _4339_/X _4459_/X VGND VGND VPWR VPWR _8821_/D sky130_fd_sc_hd__a22o_1
X_4391_ _4430_/A VGND VGND VPWR VPWR _4409_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_7_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_131_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6130_ _9065_/Q VGND VGND VPWR VPWR _6245_/A sky130_fd_sc_hd__inv_2
XFILLER_112_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6061_ _6982_/X _6061_/B VGND VGND VPWR VPWR _6065_/A sky130_fd_sc_hd__nor2_1
Xrepeater113 _7505_/S1 VGND VGND VPWR VPWR _7665_/S1 sky130_fd_sc_hd__buf_8
X_5012_ _5026_/A VGND VGND VPWR VPWR _5012_/X sky130_fd_sc_hd__clkbuf_2
Xrepeater124 _8015_/S0 VGND VGND VPWR VPWR _7949_/S0 sky130_fd_sc_hd__buf_8
Xrepeater135 _7710_/S0 VGND VGND VPWR VPWR _7909_/S0 sky130_fd_sc_hd__buf_6
XFILLER_38_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater168 _7349_/S1 VGND VGND VPWR VPWR _7288_/S1 sky130_fd_sc_hd__buf_8
Xrepeater157 _7291_/S0 VGND VGND VPWR VPWR _7341_/S0 sky130_fd_sc_hd__buf_8
Xrepeater146 repeater147/X VGND VGND VPWR VPWR repeater146/X sky130_fd_sc_hd__buf_8
XFILLER_39_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrepeater179 _7339_/S0 VGND VGND VPWR VPWR _7340_/S0 sky130_fd_sc_hd__buf_8
X_6963_ _7021_/X _7024_/X _6963_/S VGND VGND VPWR VPWR _6963_/X sky130_fd_sc_hd__mux2_1
X_8702_ _8734_/CLK _8702_/D VGND VGND VPWR VPWR _8702_/Q sky130_fd_sc_hd__dfxtp_1
X_5914_ _5914_/A _5914_/B VGND VGND VPWR VPWR _5914_/Y sky130_fd_sc_hd__nor2_1
X_6894_ _6934_/X _6931_/X _6939_/S VGND VGND VPWR VPWR _6894_/X sky130_fd_sc_hd__mux2_1
X_5845_ _5958_/A VGND VGND VPWR VPWR _6110_/C sky130_fd_sc_hd__clkbuf_2
X_8633_ _8729_/CLK _8633_/D VGND VGND VPWR VPWR _8633_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5776_ _5776_/A VGND VGND VPWR VPWR _5848_/A sky130_fd_sc_hd__inv_2
XFILLER_21_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8564_ _8786_/CLK _8564_/D VGND VGND VPWR VPWR _8564_/Q sky130_fd_sc_hd__dfxtp_1
X_7515_ _8711_/Q _8679_/Q _8647_/Q _8615_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7515_/X sky130_fd_sc_hd__mux4_2
X_8495_ _8782_/CLK _8495_/D VGND VGND VPWR VPWR _8495_/Q sky130_fd_sc_hd__dfxtp_1
X_4727_ _8666_/Q _4725_/X _4602_/X _4726_/X VGND VGND VPWR VPWR _8666_/D sky130_fd_sc_hd__a22o_1
XFILLER_135_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4658_ _8707_/Q _4649_/X _4657_/X _4651_/X VGND VGND VPWR VPWR _8707_/D sky130_fd_sc_hd__a22o_1
X_7446_ _7442_/X _7443_/X _7444_/X _7445_/X _7611_/S0 _7611_/S1 VGND VGND VPWR VPWR
+ _7446_/X sky130_fd_sc_hd__mux4_2
X_4589_ _4649_/A VGND VGND VPWR VPWR _4651_/A sky130_fd_sc_hd__inv_4
XFILLER_122_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7377_ _8606_/Q _8158_/Q _8510_/Q _8798_/Q _7389_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7377_/X sky130_fd_sc_hd__mux4_1
XFILLER_131_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6328_ _6329_/B VGND VGND VPWR VPWR _6328_/Y sky130_fd_sc_hd__inv_2
XFILLER_131_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6259_ _6932_/S _6259_/B VGND VGND VPWR VPWR _6259_/Y sky130_fd_sc_hd__nand2_2
X_9047_ _9049_/CLK _9047_/D VGND VGND VPWR VPWR _9047_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_130_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_90_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_opt_0_clk clkbuf_opt_0_clk/A VGND VGND VPWR VPWR clkbuf_opt_0_clk/X sky130_fd_sc_hd__clkbuf_16
X_5630_ _5666_/A VGND VGND VPWR VPWR _5667_/A sky130_fd_sc_hd__inv_2
XFILLER_129_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5561_ _8173_/Q _5556_/X _5450_/X _5557_/X VGND VGND VPWR VPWR _8173_/D sky130_fd_sc_hd__a22o_1
XFILLER_117_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5492_ _8220_/Q _5484_/X _5414_/X _5488_/X VGND VGND VPWR VPWR _8220_/D sky130_fd_sc_hd__a22o_1
X_8280_ _8952_/CLK _8280_/D VGND VGND VPWR VPWR _8280_/Q sky130_fd_sc_hd__dfxtp_1
X_4512_ _8786_/Q _4507_/X _4346_/X _4508_/X VGND VGND VPWR VPWR _8786_/D sky130_fd_sc_hd__a22o_1
X_7300_ _8982_/Q _8406_/Q _8182_/Q _8758_/Q _7339_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7300_/X sky130_fd_sc_hd__mux4_1
XFILLER_8_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7231_ _7227_/X _7228_/X _7229_/X _7230_/X _7241_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7231_/X sky130_fd_sc_hd__mux4_2
XFILLER_104_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4443_ _4479_/A VGND VGND VPWR VPWR _4480_/A sky130_fd_sc_hd__clkinv_4
X_7162_ _8809_/Q _8329_/Q _8937_/Q _8457_/Q _7185_/S0 _7185_/S1 VGND VGND VPWR VPWR
+ _7162_/X sky130_fd_sc_hd__mux4_2
XFILLER_113_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4374_ _4374_/A VGND VGND VPWR VPWR _4374_/X sky130_fd_sc_hd__clkbuf_2
X_7093_ _8418_/Q _8290_/Q _8354_/Q _8546_/Q _7130_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7093_/X sky130_fd_sc_hd__mux4_1
XFILLER_113_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6113_ _6329_/A VGND VGND VPWR VPWR _6185_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_113_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6044_ _6044_/A VGND VGND VPWR VPWR _6045_/A sky130_fd_sc_hd__inv_2
XFILLER_39_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7995_ _8735_/Q _8703_/Q _8671_/Q _8639_/Q _7995_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7995_/X sky130_fd_sc_hd__mux4_2
XFILLER_81_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6946_ _6945_/X _6971_/X _6964_/S VGND VGND VPWR VPWR _6946_/X sky130_fd_sc_hd__mux2_1
XFILLER_26_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6877_ _6876_/X _6881_/X _6949_/S VGND VGND VPWR VPWR _6877_/X sky130_fd_sc_hd__mux2_1
XFILLER_50_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8616_ _8873_/CLK _8616_/D VGND VGND VPWR VPWR _8616_/Q sky130_fd_sc_hd__dfxtp_1
X_5828_ _5828_/A VGND VGND VPWR VPWR _5828_/Y sky130_fd_sc_hd__inv_2
XFILLER_22_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5759_ _8041_/Q _5755_/X _4643_/A _5756_/X VGND VGND VPWR VPWR _8041_/D sky130_fd_sc_hd__a22o_1
X_8547_ _8932_/CLK _8547_/D VGND VGND VPWR VPWR _8547_/Q sky130_fd_sc_hd__dfxtp_1
X_8478_ _8669_/CLK _8478_/D VGND VGND VPWR VPWR _8478_/Q sky130_fd_sc_hd__dfxtp_1
X_7429_ _8098_/Q _8066_/Q _8034_/Q _9026_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7429_/X sky130_fd_sc_hd__mux4_1
XFILLER_118_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4090_ _6782_/X VGND VGND VPWR VPWR _4655_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6800_ _6611_/Y _6625_/Y _6809_/S VGND VGND VPWR VPWR _6800_/X sky130_fd_sc_hd__mux2_2
XFILLER_90_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4992_ _5006_/A VGND VGND VPWR VPWR _4992_/X sky130_fd_sc_hd__clkbuf_2
X_7780_ _8980_/Q _8404_/Q _8180_/Q _8756_/Q _7875_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7780_/X sky130_fd_sc_hd__mux4_1
X_6731_ _6730_/X _9080_/Q _6733_/S VGND VGND VPWR VPWR _6731_/X sky130_fd_sc_hd__mux2_4
X_6662_ _6528_/A _6661_/X _6531_/A VGND VGND VPWR VPWR _6662_/X sky130_fd_sc_hd__o21a_1
X_5613_ _8139_/Q _5611_/X _5455_/X _5612_/X VGND VGND VPWR VPWR _8139_/D sky130_fd_sc_hd__a22o_1
X_8401_ _9009_/CLK _8401_/D VGND VGND VPWR VPWR _8401_/Q sky130_fd_sc_hd__dfxtp_1
X_8332_ _8940_/CLK _8332_/D VGND VGND VPWR VPWR _8332_/Q sky130_fd_sc_hd__dfxtp_1
X_6593_ _6461_/A _6482_/X _6585_/X VGND VGND VPWR VPWR _6593_/Y sky130_fd_sc_hd__o21ai_1
X_5544_ _8186_/Q _5542_/X _5419_/X _5543_/X VGND VGND VPWR VPWR _8186_/D sky130_fd_sc_hd__a22o_1
X_8263_ _8999_/CLK _8263_/D VGND VGND VPWR VPWR _8263_/Q sky130_fd_sc_hd__dfxtp_1
X_5475_ _8227_/Q _5466_/X _5474_/X _5468_/X VGND VGND VPWR VPWR _8227_/D sky130_fd_sc_hd__a22o_1
X_4426_ _8842_/Q _4423_/X _4366_/X _4424_/X VGND VGND VPWR VPWR _8842_/D sky130_fd_sc_hd__a22o_1
X_8194_ _8994_/CLK _8194_/D VGND VGND VPWR VPWR _8194_/Q sky130_fd_sc_hd__dfxtp_1
X_7214_ _8526_/Q _8910_/Q _8846_/Q _8878_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7214_/X sky130_fd_sc_hd__mux4_1
X_7145_ _8711_/Q _8679_/Q _8647_/Q _8615_/Q _7185_/S0 _7185_/S1 VGND VGND VPWR VPWR
+ _7145_/X sky130_fd_sc_hd__mux4_2
XFILLER_59_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4357_ _8878_/Q _4350_/X _4356_/X _4352_/X VGND VGND VPWR VPWR _8878_/D sky130_fd_sc_hd__a22o_1
XFILLER_48_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4288_ _4302_/A VGND VGND VPWR VPWR _4288_/X sky130_fd_sc_hd__buf_2
X_7076_ _7072_/X _7073_/X _7074_/X _7075_/X _7286_/S0 _7381_/S1 VGND VGND VPWR VPWR
+ _7076_/X sky130_fd_sc_hd__mux4_1
XFILLER_59_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6027_ _6655_/A _6010_/A _6016_/A _6020_/X _6018_/X VGND VGND VPWR VPWR _6027_/X
+ sky130_fd_sc_hd__o2111a_1
XFILLER_67_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7978_ _8286_/Q _8254_/Q _8222_/Q _9022_/Q _8025_/S0 _5772_/B VGND VGND VPWR VPWR
+ _7978_/X sky130_fd_sc_hd__mux4_1
XFILLER_81_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6929_ _6931_/X _6930_/X _6939_/S VGND VGND VPWR VPWR _6929_/X sky130_fd_sc_hd__mux2_1
XPHY_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5260_ _5298_/A VGND VGND VPWR VPWR _5277_/A sky130_fd_sc_hd__clkbuf_4
X_4211_ _5723_/B VGND VGND VPWR VPWR _5210_/A sky130_fd_sc_hd__buf_1
XFILLER_79_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5191_ _8392_/Q _5182_/X _5190_/X _5184_/X VGND VGND VPWR VPWR _8392_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4142_ _4149_/A VGND VGND VPWR VPWR _4142_/X sky130_fd_sc_hd__buf_2
X_4073_ _6787_/X VGND VGND VPWR VPWR _4643_/A sky130_fd_sc_hd__clkbuf_2
X_8950_ _8950_/CLK _8950_/D VGND VGND VPWR VPWR _8950_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_95_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7901_ _7897_/X _7898_/X _7899_/X _7900_/X _7901_/S0 _8031_/S1 VGND VGND VPWR VPWR
+ _7901_/X sky130_fd_sc_hd__mux4_2
X_8881_ _9024_/CLK _8881_/D VGND VGND VPWR VPWR _8881_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_48_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7832_ _8823_/Q _8343_/Q _8951_/Q _8471_/Q _7894_/S0 _7897_/S1 VGND VGND VPWR VPWR
+ _7832_/X sky130_fd_sc_hd__mux4_1
X_4975_ _8521_/Q _4971_/X _4916_/X _4972_/X VGND VGND VPWR VPWR _8521_/D sky130_fd_sc_hd__a22o_1
XFILLER_24_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7763_ _8435_/Q _8307_/Q _8371_/Q _8563_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7763_/X sky130_fd_sc_hd__mux4_1
XPHY_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6714_ _7236_/X _7241_/X _6714_/S VGND VGND VPWR VPWR _6714_/X sky130_fd_sc_hd__mux2_1
X_7694_ _8528_/Q _8912_/Q _8848_/Q _8880_/Q _7697_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7694_/X sky130_fd_sc_hd__mux4_1
X_6645_ _6604_/X _7016_/X VGND VGND VPWR VPWR _6645_/Y sky130_fd_sc_hd__nand2b_1
X_6576_ _6473_/Y _5970_/A _6582_/A _6475_/Y VGND VGND VPWR VPWR _6576_/X sky130_fd_sc_hd__o22a_1
XFILLER_106_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8315_ _8956_/CLK _8315_/D VGND VGND VPWR VPWR _8315_/Q sky130_fd_sc_hd__dfxtp_1
X_5527_ _8195_/Q _5522_/X _5474_/X _5523_/X VGND VGND VPWR VPWR _8195_/D sky130_fd_sc_hd__a22o_1
XFILLER_133_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8246_ _8986_/CLK _8246_/D VGND VGND VPWR VPWR _8246_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_132_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5458_ _6788_/X VGND VGND VPWR VPWR _5458_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_133_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5389_ _8267_/Q _5387_/X _5183_/X _5388_/X VGND VGND VPWR VPWR _8267_/D sky130_fd_sc_hd__a22o_1
X_8177_ _9009_/CLK _8177_/D VGND VGND VPWR VPWR _8177_/Q sky130_fd_sc_hd__dfxtp_1
X_4409_ _4409_/A VGND VGND VPWR VPWR _4409_/X sky130_fd_sc_hd__clkbuf_2
X_7128_ _8261_/Q _8229_/Q _8197_/Q _8997_/Q _7130_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7128_/X sky130_fd_sc_hd__mux4_2
XFILLER_87_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7059_ _7956_/X _7961_/X _7059_/S VGND VGND VPWR VPWR _7059_/X sky130_fd_sc_hd__mux2_1
XFILLER_86_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4760_ _8641_/Q _4732_/A _4661_/X _4733_/A VGND VGND VPWR VPWR _8641_/D sky130_fd_sc_hd__a22o_1
XFILLER_33_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4691_ _4705_/A VGND VGND VPWR VPWR _4691_/X sky130_fd_sc_hd__clkbuf_2
X_6430_ _6430_/A _6430_/B VGND VGND VPWR VPWR _6777_/S sky130_fd_sc_hd__or2_4
X_6361_ _6222_/B _6360_/X _6217_/X VGND VGND VPWR VPWR _6361_/X sky130_fd_sc_hd__o21a_1
XFILLER_115_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5312_ _5326_/A VGND VGND VPWR VPWR _5312_/X sky130_fd_sc_hd__clkbuf_2
X_8100_ _9004_/CLK _8100_/D VGND VGND VPWR VPWR _8100_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_114_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6292_ _3986_/A _6290_/X _3986_/A _6290_/X VGND VGND VPWR VPWR _6292_/X sky130_fd_sc_hd__o2bb2a_1
X_9080_ _9080_/CLK _9080_/D repeater147/X VGND VGND VPWR VPWR _9080_/Q sky130_fd_sc_hd__dfrtp_2
X_5243_ _5250_/A VGND VGND VPWR VPWR _5243_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_115_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8031_ _8027_/X _8028_/X _8029_/X _8030_/X _8031_/S0 _8031_/S1 VGND VGND VPWR VPWR
+ _8031_/X sky130_fd_sc_hd__mux4_2
XFILLER_114_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5174_ _6793_/X VGND VGND VPWR VPWR _5174_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_69_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4125_ _9015_/Q _4120_/X _4026_/X _4121_/X VGND VGND VPWR VPWR _9015_/D sky130_fd_sc_hd__a22o_1
XFILLER_29_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8933_ _8933_/CLK _8933_/D VGND VGND VPWR VPWR _8933_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_84_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4056_ _6792_/X VGND VGND VPWR VPWR _4631_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_71_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8864_ _8960_/CLK _8864_/D VGND VGND VPWR VPWR _8864_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7815_ _8726_/Q _8694_/Q _8662_/Q _8630_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7815_/X sky130_fd_sc_hd__mux4_2
X_8795_ _8956_/CLK _8795_/D VGND VGND VPWR VPWR _8795_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7746_ _7742_/X _7743_/X _7744_/X _7745_/X _7811_/S0 _8021_/S1 VGND VGND VPWR VPWR
+ _7746_/X sky130_fd_sc_hd__mux4_2
X_4958_ _4958_/A VGND VGND VPWR VPWR _4958_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_138_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4889_ _8565_/Q _4886_/X _4887_/X _4888_/X VGND VGND VPWR VPWR _8565_/D sky130_fd_sc_hd__a22o_1
X_7677_ _8591_/Q _8143_/Q _8495_/Q _8783_/Q _7700_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7677_/X sky130_fd_sc_hd__mux4_2
X_6628_ _6879_/X _6620_/X _6985_/X _6606_/X _6627_/Y VGND VGND VPWR VPWR _6628_/Y
+ sky130_fd_sc_hd__o221ai_2
X_6559_ _6570_/A _6559_/B VGND VGND VPWR VPWR _6560_/A sky130_fd_sc_hd__or2_1
XFILLER_105_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8229_ _8994_/CLK _8229_/D VGND VGND VPWR VPWR _8229_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_79_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_2152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5930_ _5832_/D _5832_/B _5831_/A _5810_/A VGND VGND VPWR VPWR _5930_/X sky130_fd_sc_hd__o22a_1
XFILLER_53_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7600_ _8971_/Q _8395_/Q _8171_/Q _8747_/Q _7600_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7600_/X sky130_fd_sc_hd__mux4_1
X_5861_ _6985_/X _5861_/B VGND VGND VPWR VPWR _5862_/B sky130_fd_sc_hd__nand2_1
XFILLER_34_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8580_ _8966_/CLK _8580_/D VGND VGND VPWR VPWR _8580_/Q sky130_fd_sc_hd__dfxtp_1
X_5792_ _5788_/Y _5793_/A _5790_/Y _5795_/A VGND VGND VPWR VPWR _5792_/X sky130_fd_sc_hd__a211o_1
X_4812_ _4828_/A VGND VGND VPWR VPWR _4812_/X sky130_fd_sc_hd__clkbuf_2
X_7531_ _7527_/X _7528_/X _7529_/X _7530_/X _7611_/S0 _7611_/S1 VGND VGND VPWR VPWR
+ _7531_/X sky130_fd_sc_hd__mux4_1
X_4743_ _8654_/Q _4739_/X _4631_/X _4740_/X VGND VGND VPWR VPWR _8654_/D sky130_fd_sc_hd__a22o_1
X_7462_ _8804_/Q _8324_/Q _8932_/Q _8452_/Q _7610_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7462_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4674_ _8701_/Q _4667_/X _4595_/X _4671_/X VGND VGND VPWR VPWR _8701_/D sky130_fd_sc_hd__a22o_1
X_6413_ _3989_/A _6287_/Y _6289_/A VGND VGND VPWR VPWR _6413_/X sky130_fd_sc_hd__o21a_1
X_7393_ _8417_/Q _8289_/Q _8353_/Q _8545_/Q _5771_/A _5772_/B VGND VGND VPWR VPWR
+ _7393_/X sky130_fd_sc_hd__mux4_2
X_6344_ _6744_/S _6344_/B _6344_/C VGND VGND VPWR VPWR _6745_/S sky130_fd_sc_hd__nor3_4
XFILLER_1_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6275_ _3981_/A _6274_/Y _3982_/A _6274_/A VGND VGND VPWR VPWR _6297_/A sky130_fd_sc_hd__a22o_1
XFILLER_88_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9063_ _9063_/CLK _9063_/D repeater146/X VGND VGND VPWR VPWR _9063_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_103_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8014_ _8512_/Q _8896_/Q _8832_/Q _8864_/Q _8015_/S0 _5872_/B VGND VGND VPWR VPWR
+ _8014_/X sky130_fd_sc_hd__mux4_1
X_5226_ _8376_/Q _5222_/X _5152_/X _5223_/X VGND VGND VPWR VPWR _8376_/D sky130_fd_sc_hd__a22o_1
XFILLER_57_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5157_ _8406_/Q _5146_/X _5156_/X _5148_/X VGND VGND VPWR VPWR _8406_/D sky130_fd_sc_hd__a22o_1
X_5088_ _5102_/A VGND VGND VPWR VPWR _5088_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_84_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4108_ _4148_/A VGND VGND VPWR VPWR _4127_/A sky130_fd_sc_hd__buf_4
XFILLER_56_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4039_ _6797_/X VGND VGND VPWR VPWR _4619_/A sky130_fd_sc_hd__buf_1
X_8916_ _8947_/CLK _8916_/D VGND VGND VPWR VPWR _8916_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_44_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8847_ _8911_/CLK _8847_/D VGND VGND VPWR VPWR _8847_/Q sky130_fd_sc_hd__dfxtp_1
X_8778_ _8778_/CLK _8778_/D VGND VGND VPWR VPWR _8778_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7729_ _8113_/Q _8081_/Q _8049_/Q _9041_/Q _7885_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7729_/X sky130_fd_sc_hd__mux4_1
XFILLER_40_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_113_clk clkbuf_4_2_0_clk/X VGND VGND VPWR VPWR _9050_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_138_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_101_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_104_clk _8032_/CLK VGND VGND VPWR VPWR _8822_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_117_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4390_ _5210_/A _4938_/B VGND VGND VPWR VPWR _4430_/A sky130_fd_sc_hd__or2_4
XFILLER_112_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6060_ _6994_/X _5900_/B _6991_/X _5908_/B VGND VGND VPWR VPWR _6060_/X sky130_fd_sc_hd__a22o_1
XFILLER_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xrepeater114 _7609_/S1 VGND VGND VPWR VPWR _7505_/S1 sky130_fd_sc_hd__clkbuf_8
Xrepeater103 _6943_/S VGND VGND VPWR VPWR _6830_/S sky130_fd_sc_hd__clkbuf_8
XFILLER_78_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater125 _8015_/S0 VGND VGND VPWR VPWR _5872_/C sky130_fd_sc_hd__buf_6
XFILLER_38_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5011_ _8497_/Q _5005_/X _4896_/X _5006_/X VGND VGND VPWR VPWR _8497_/D sky130_fd_sc_hd__a22o_1
XFILLER_66_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater158 _7286_/S0 VGND VGND VPWR VPWR _7291_/S0 sky130_fd_sc_hd__buf_6
Xrepeater147 input38/X VGND VGND VPWR VPWR repeater147/X sky130_fd_sc_hd__buf_8
Xrepeater136 _7689_/S0 VGND VGND VPWR VPWR _7710_/S0 sky130_fd_sc_hd__buf_8
XFILLER_93_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrepeater169 _7390_/S1 VGND VGND VPWR VPWR _7349_/S1 sky130_fd_sc_hd__clkbuf_8
XFILLER_26_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6962_ _7027_/X _7030_/X _6963_/S VGND VGND VPWR VPWR _6962_/X sky130_fd_sc_hd__mux2_1
XFILLER_47_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8701_ _8734_/CLK _8701_/D VGND VGND VPWR VPWR _8701_/Q sky130_fd_sc_hd__dfxtp_1
X_5913_ _6110_/C VGND VGND VPWR VPWR _5913_/X sky130_fd_sc_hd__clkbuf_2
X_6893_ _6895_/X _6894_/X _6932_/S VGND VGND VPWR VPWR _6893_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8632_ _8757_/CLK _8632_/D VGND VGND VPWR VPWR _8632_/Q sky130_fd_sc_hd__dfxtp_1
X_5844_ _5946_/A VGND VGND VPWR VPWR _5844_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8563_ _8882_/CLK _8563_/D VGND VGND VPWR VPWR _8563_/Q sky130_fd_sc_hd__dfxtp_1
X_7514_ _8519_/Q _8903_/Q _8839_/Q _8871_/Q _7594_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7514_/X sky130_fd_sc_hd__mux4_2
X_5775_ _7002_/X _6040_/B VGND VGND VPWR VPWR _5776_/A sky130_fd_sc_hd__nand2_1
XFILLER_10_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8494_ _8781_/CLK _8494_/D VGND VGND VPWR VPWR _8494_/Q sky130_fd_sc_hd__dfxtp_1
X_4726_ _4733_/A VGND VGND VPWR VPWR _4726_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_135_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7445_ _8707_/Q _8675_/Q _8643_/Q _8611_/Q _7610_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7445_/X sky130_fd_sc_hd__mux4_2
X_4657_ _4657_/A VGND VGND VPWR VPWR _4657_/X sky130_fd_sc_hd__clkbuf_2
X_7376_ _7372_/X _7373_/X _7374_/X _7375_/X _6343_/C _6343_/B VGND VGND VPWR VPWR
+ _7376_/X sky130_fd_sc_hd__mux4_2
XFILLER_122_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4588_ _4613_/A VGND VGND VPWR VPWR _4588_/X sky130_fd_sc_hd__clkbuf_2
X_6327_ _9082_/Q _6163_/B _6164_/A VGND VGND VPWR VPWR _6329_/B sky130_fd_sc_hd__o21ai_1
XFILLER_115_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6258_ _6255_/A _6255_/B _6255_/Y VGND VGND VPWR VPWR _6259_/B sky130_fd_sc_hd__a21oi_4
X_9046_ _9048_/CLK _9046_/D VGND VGND VPWR VPWR _9046_/Q sky130_fd_sc_hd__dfxtp_1
X_5209_ _8384_/Q _5158_/A _5208_/X _5160_/A VGND VGND VPWR VPWR _8384_/D sky130_fd_sc_hd__a22o_1
X_6189_ _6191_/B VGND VGND VPWR VPWR _6189_/Y sky130_fd_sc_hd__inv_2
XFILLER_57_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5560_ _8174_/Q _5556_/X _5448_/X _5557_/X VGND VGND VPWR VPWR _8174_/D sky130_fd_sc_hd__a22o_1
XPHY_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5491_ _8221_/Q _5484_/X _5412_/X _5488_/X VGND VGND VPWR VPWR _8221_/D sky130_fd_sc_hd__a22o_1
X_4511_ _8787_/Q _4507_/X _4344_/X _4508_/X VGND VGND VPWR VPWR _8787_/D sky130_fd_sc_hd__a22o_1
X_4442_ _4458_/A VGND VGND VPWR VPWR _4442_/X sky130_fd_sc_hd__buf_2
X_7230_ _8975_/Q _8399_/Q _8175_/Q _8751_/Q _7240_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7230_/X sky130_fd_sc_hd__mux4_1
XFILLER_132_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7161_ _7157_/X _7158_/X _7159_/X _7160_/X _7191_/S0 _7381_/S1 VGND VGND VPWR VPWR
+ _7161_/X sky130_fd_sc_hd__mux4_2
X_4373_ _8871_/Q _4362_/X _4372_/X _4364_/X VGND VGND VPWR VPWR _8871_/D sky130_fd_sc_hd__a22o_1
X_7092_ _8802_/Q _8322_/Q _8930_/Q _8450_/Q _7130_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7092_/X sky130_fd_sc_hd__mux4_1
XFILLER_98_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6112_ _6217_/A VGND VGND VPWR VPWR _6329_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_112_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6043_ _7005_/X _6043_/B VGND VGND VPWR VPWR _6044_/A sky130_fd_sc_hd__nand2_2
XFILLER_85_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7994_ _8543_/Q _8927_/Q _8863_/Q _8895_/Q _7995_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7994_/X sky130_fd_sc_hd__mux4_1
XFILLER_81_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6945_ _6944_/X _6974_/X _6971_/S VGND VGND VPWR VPWR _6945_/X sky130_fd_sc_hd__mux2_1
XFILLER_41_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6876_ _6971_/X _6968_/X _6964_/S VGND VGND VPWR VPWR _6876_/X sky130_fd_sc_hd__mux2_1
X_8615_ _8873_/CLK _8615_/D VGND VGND VPWR VPWR _8615_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_139_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5827_ _5827_/A _5827_/B VGND VGND VPWR VPWR _5828_/A sky130_fd_sc_hd__nand2_1
X_5758_ _8042_/Q _5755_/X _4641_/A _5756_/X VGND VGND VPWR VPWR _8042_/D sky130_fd_sc_hd__a22o_1
X_8546_ _8934_/CLK _8546_/D VGND VGND VPWR VPWR _8546_/Q sky130_fd_sc_hd__dfxtp_1
X_4709_ _8676_/Q _4705_/X _4655_/X _4706_/X VGND VGND VPWR VPWR _8676_/D sky130_fd_sc_hd__a22o_1
X_8477_ _8863_/CLK _8477_/D VGND VGND VPWR VPWR _8477_/Q sky130_fd_sc_hd__dfxtp_1
X_7428_ _8258_/Q _8226_/Q _8194_/Q _8994_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7428_/X sky130_fd_sc_hd__mux4_1
X_5689_ _8089_/Q _5686_/X _4605_/A _5687_/X VGND VGND VPWR VPWR _8089_/D sky130_fd_sc_hd__a22o_1
X_7359_ _8124_/Q _8092_/Q _8060_/Q _9052_/Q _7359_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7359_/X sky130_fd_sc_hd__mux4_2
XFILLER_131_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9029_ _9029_/CLK _9029_/D VGND VGND VPWR VPWR _9029_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4991_ _5027_/A VGND VGND VPWR VPWR _5006_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_51_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6730_ _7316_/X _7321_/X _6734_/S VGND VGND VPWR VPWR _6730_/X sky130_fd_sc_hd__mux2_1
X_6661_ _5886_/A _6514_/A _6528_/B VGND VGND VPWR VPWR _6661_/X sky130_fd_sc_hd__o21a_1
XFILLER_31_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5612_ _5619_/A VGND VGND VPWR VPWR _5612_/X sky130_fd_sc_hd__buf_2
X_6592_ _6410_/X _7028_/X VGND VGND VPWR VPWR _6592_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_31_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8400_ _8975_/CLK _8400_/D VGND VGND VPWR VPWR _8400_/Q sky130_fd_sc_hd__dfxtp_1
X_8331_ _8811_/CLK _8331_/D VGND VGND VPWR VPWR _8331_/Q sky130_fd_sc_hd__dfxtp_1
X_5543_ _5550_/A VGND VGND VPWR VPWR _5543_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_129_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5474_ _6781_/X VGND VGND VPWR VPWR _5474_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_105_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8262_ _9028_/CLK _8262_/D VGND VGND VPWR VPWR _8262_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_132_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4425_ _8843_/Q _4423_/X _4363_/X _4424_/X VGND VGND VPWR VPWR _8843_/D sky130_fd_sc_hd__a22o_1
X_8193_ _9054_/CLK _8193_/D VGND VGND VPWR VPWR _8193_/Q sky130_fd_sc_hd__dfxtp_1
X_7213_ _8430_/Q _8302_/Q _8366_/Q _8558_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7213_/X sky130_fd_sc_hd__mux4_1
XFILLER_132_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7144_ _8519_/Q _8903_/Q _8839_/Q _8871_/Q _7184_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7144_/X sky130_fd_sc_hd__mux4_1
X_4356_ _4631_/A VGND VGND VPWR VPWR _4356_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_100_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7075_ _8704_/Q _8672_/Q _8640_/Q _8608_/Q _7369_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7075_/X sky130_fd_sc_hd__mux4_1
XFILLER_58_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4287_ _8913_/Q _4281_/X _4046_/X _4282_/X VGND VGND VPWR VPWR _8913_/D sky130_fd_sc_hd__a22o_1
XFILLER_86_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6026_ _7021_/X VGND VGND VPWR VPWR _6655_/A sky130_fd_sc_hd__inv_2
XFILLER_100_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_93_clk clkbuf_4_8_0_clk/X VGND VGND VPWR VPWR _9080_/CLK sky130_fd_sc_hd__clkbuf_16
X_7977_ _8606_/Q _8158_/Q _8510_/Q _8798_/Q _8025_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7977_/X sky130_fd_sc_hd__mux4_2
XFILLER_42_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6928_ _7036_/X _7039_/X _6963_/S VGND VGND VPWR VPWR _6928_/X sky130_fd_sc_hd__mux2_1
XPHY_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6859_ _6891_/X _6889_/X _6964_/S VGND VGND VPWR VPWR _6859_/X sky130_fd_sc_hd__mux2_1
XPHY_1858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8529_ _8945_/CLK _8529_/D VGND VGND VPWR VPWR _8529_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_129_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_84_clk _8944_/CLK VGND VGND VPWR VPWR _8911_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_45_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4210_ _6813_/X _6814_/X _4210_/C VGND VGND VPWR VPWR _5723_/B sky130_fd_sc_hd__or3_4
XFILLER_96_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5190_ _6786_/X VGND VGND VPWR VPWR _5190_/X sky130_fd_sc_hd__buf_2
XFILLER_68_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4141_ _4148_/A VGND VGND VPWR VPWR _4141_/X sky130_fd_sc_hd__buf_2
X_4072_ _9034_/Q _4068_/X _4070_/X _4071_/X VGND VGND VPWR VPWR _9034_/D sky130_fd_sc_hd__a22o_1
XFILLER_96_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7900_ _8986_/Q _8410_/Q _8186_/Q _8762_/Q _7900_/S0 _7900_/S1 VGND VGND VPWR VPWR
+ _7900_/X sky130_fd_sc_hd__mux4_1
XFILLER_36_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_75_clk clkbuf_opt_0_clk/A VGND VGND VPWR VPWR _9038_/CLK sky130_fd_sc_hd__clkbuf_16
X_8880_ _8943_/CLK _8880_/D VGND VGND VPWR VPWR _8880_/Q sky130_fd_sc_hd__dfxtp_1
X_7831_ _7827_/X _7828_/X _7829_/X _7830_/X _5872_/A input11/X VGND VGND VPWR VPWR
+ _7831_/X sky130_fd_sc_hd__mux4_2
X_4974_ _8522_/Q _4971_/X _4914_/X _4972_/X VGND VGND VPWR VPWR _8522_/D sky130_fd_sc_hd__a22o_1
XFILLER_17_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7762_ _8819_/Q _8339_/Q _8947_/Q _8467_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7762_/X sky130_fd_sc_hd__mux4_1
X_6713_ _6712_/X _9071_/Q _6735_/S VGND VGND VPWR VPWR _6713_/X sky130_fd_sc_hd__mux2_1
X_7693_ _8432_/Q _8304_/Q _8368_/Q _8560_/Q _7697_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7693_/X sky130_fd_sc_hd__mux4_1
X_6644_ _6536_/A _6643_/A _6536_/Y _6643_/Y VGND VGND VPWR VPWR _6644_/X sky130_fd_sc_hd__o22a_1
X_6575_ _6465_/A _6465_/B _6466_/Y VGND VGND VPWR VPWR _6575_/X sky130_fd_sc_hd__a21o_1
XFILLER_118_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5526_ _8196_/Q _5522_/X _5472_/X _5523_/X VGND VGND VPWR VPWR _8196_/D sky130_fd_sc_hd__a22o_1
X_8314_ _9050_/CLK _8314_/D VGND VGND VPWR VPWR _8314_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5457_ _8235_/Q _5454_/X _5455_/X _5456_/X VGND VGND VPWR VPWR _8235_/D sky130_fd_sc_hd__a22o_1
X_8245_ _9044_/CLK _8245_/D VGND VGND VPWR VPWR _8245_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_132_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4408_ _8854_/Q _4402_/X _4336_/X _4403_/X VGND VGND VPWR VPWR _8854_/D sky130_fd_sc_hd__a22o_1
XFILLER_132_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5388_ _5395_/A VGND VGND VPWR VPWR _5388_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_59_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8176_ _8975_/CLK _8176_/D VGND VGND VPWR VPWR _8176_/Q sky130_fd_sc_hd__dfxtp_1
X_7127_ _8581_/Q _8133_/Q _8485_/Q _8773_/Q _7130_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7127_/X sky130_fd_sc_hd__mux4_1
X_4339_ _4614_/A VGND VGND VPWR VPWR _4339_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_115_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7058_ _7946_/X _7951_/X _7067_/S VGND VGND VPWR VPWR _7058_/X sky130_fd_sc_hd__mux2_2
XFILLER_59_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6009_ _7020_/X _6037_/B VGND VGND VPWR VPWR _6010_/A sky130_fd_sc_hd__nand2_2
Xclkbuf_leaf_66_clk clkbuf_4_14_0_clk/X VGND VGND VPWR VPWR _8940_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_27_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_57_clk clkbuf_4_15_0_clk/X VGND VGND VPWR VPWR _8709_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_46_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4690_ _8689_/Q _4684_/X _4623_/X _4685_/X VGND VGND VPWR VPWR _8689_/D sky130_fd_sc_hd__a22o_1
X_6360_ _6222_/A _6359_/X _6316_/X VGND VGND VPWR VPWR _6360_/X sky130_fd_sc_hd__o21a_1
X_5311_ _5347_/A VGND VGND VPWR VPWR _5326_/A sky130_fd_sc_hd__clkbuf_4
X_6291_ _6291_/A _6291_/B VGND VGND VPWR VPWR _6291_/Y sky130_fd_sc_hd__nor2_2
X_8030_ _8960_/Q _8384_/Q _8160_/Q _8736_/Q _8030_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _8030_/X sky130_fd_sc_hd__mux4_1
XFILLER_5_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5242_ _8364_/Q _5236_/X _5180_/X _5237_/X VGND VGND VPWR VPWR _8364_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5173_ _8400_/Q _5170_/X _5171_/X _5172_/X VGND VGND VPWR VPWR _8400_/D sky130_fd_sc_hd__a22o_1
XFILLER_110_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4124_ _9016_/Q _4120_/X _4023_/X _4121_/X VGND VGND VPWR VPWR _9016_/D sky130_fd_sc_hd__a22o_1
XFILLER_110_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput1 imData[0] VGND VGND VPWR VPWR input1/X sky130_fd_sc_hd__clkbuf_4
Xclkbuf_leaf_48_clk clkbuf_4_13_0_clk/X VGND VGND VPWR VPWR _9033_/CLK sky130_fd_sc_hd__clkbuf_16
X_8932_ _8932_/CLK _8932_/D VGND VGND VPWR VPWR _8932_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_84_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4055_ _9039_/Q _4051_/X _4053_/X _4054_/X VGND VGND VPWR VPWR _9039_/D sky130_fd_sc_hd__a22o_1
XFILLER_49_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8863_ _8863_/CLK _8863_/D VGND VGND VPWR VPWR _8863_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_71_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7814_ _8534_/Q _8918_/Q _8854_/Q _8886_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7814_/X sky130_fd_sc_hd__mux4_1
XFILLER_101_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8794_ _8794_/CLK _8794_/D VGND VGND VPWR VPWR _8794_/Q sky130_fd_sc_hd__dfxtp_1
X_7745_ _8722_/Q _8690_/Q _8658_/Q _8626_/Q _7949_/S0 input9/X VGND VGND VPWR VPWR
+ _7745_/X sky130_fd_sc_hd__mux4_1
X_4957_ _4957_/A VGND VGND VPWR VPWR _4957_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_138_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4888_ _4888_/A VGND VGND VPWR VPWR _4888_/X sky130_fd_sc_hd__clkbuf_2
X_7676_ _7672_/X _7673_/X _7674_/X _7675_/X _7701_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7676_/X sky130_fd_sc_hd__mux4_2
XFILLER_138_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6627_ _6457_/A _6004_/Y _6621_/X VGND VGND VPWR VPWR _6627_/Y sky130_fd_sc_hd__o21ai_1
X_6558_ _6555_/X _6557_/X _6555_/X _6557_/X VGND VGND VPWR VPWR _6558_/Y sky130_fd_sc_hd__o2bb2ai_1
XFILLER_118_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5509_ _5523_/A VGND VGND VPWR VPWR _5509_/X sky130_fd_sc_hd__clkbuf_2
X_6489_ _6488_/Y _5986_/A _6822_/X _5986_/Y VGND VGND VPWR VPWR _6490_/A sky130_fd_sc_hd__o22a_1
XFILLER_133_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8228_ _9028_/CLK _8228_/D VGND VGND VPWR VPWR _8228_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_126_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8159_ _9052_/CLK _8159_/D VGND VGND VPWR VPWR _8159_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_39_clk clkbuf_4_6_0_clk/X VGND VGND VPWR VPWR _8545_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_28_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_97_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5860_ _5927_/A _5860_/B VGND VGND VPWR VPWR _5861_/B sky130_fd_sc_hd__nor2_2
XFILLER_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4811_ _4849_/A VGND VGND VPWR VPWR _4828_/A sky130_fd_sc_hd__buf_4
XFILLER_61_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5791_ _6990_/X _5822_/A VGND VGND VPWR VPWR _5795_/A sky130_fd_sc_hd__nand2_2
XFILLER_33_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7530_ _8967_/Q _8391_/Q _8167_/Q _8743_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7530_/X sky130_fd_sc_hd__mux4_1
X_4742_ _8655_/Q _4739_/X _4629_/X _4740_/X VGND VGND VPWR VPWR _8655_/D sky130_fd_sc_hd__a22o_1
X_4673_ _8702_/Q _4667_/X _4593_/X _4671_/X VGND VGND VPWR VPWR _8702_/D sky130_fd_sc_hd__a22o_1
X_7461_ _7457_/X _7458_/X _7459_/X _7460_/X _7501_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7461_/X sky130_fd_sc_hd__mux4_1
X_6412_ _6291_/Y _6292_/X _6291_/Y _6292_/X VGND VGND VPWR VPWR _6412_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_128_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7392_ _8801_/Q _8321_/Q _8929_/Q _8449_/Q _5771_/A _5772_/B VGND VGND VPWR VPWR
+ _7392_/X sky130_fd_sc_hd__mux4_2
X_6343_ _6343_/A _6343_/B _6343_/C VGND VGND VPWR VPWR _6344_/C sky130_fd_sc_hd__or3_4
XFILLER_89_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6274_ _6274_/A VGND VGND VPWR VPWR _6274_/Y sky130_fd_sc_hd__inv_2
X_9062_ _9062_/CLK _9062_/D repeater146/X VGND VGND VPWR VPWR _9062_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_130_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8013_ _8416_/Q _8288_/Q _8352_/Q _8544_/Q _8015_/S0 _5872_/B VGND VGND VPWR VPWR
+ _8013_/X sky130_fd_sc_hd__mux4_2
X_5225_ _8377_/Q _5222_/X _5150_/X _5223_/X VGND VGND VPWR VPWR _8377_/D sky130_fd_sc_hd__a22o_1
XFILLER_102_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5156_ _6800_/X VGND VGND VPWR VPWR _5156_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_110_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5087_ _5123_/A VGND VGND VPWR VPWR _5102_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_84_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4107_ _4537_/A _5482_/A VGND VGND VPWR VPWR _4148_/A sky130_fd_sc_hd__or2_4
X_4038_ _9044_/Q _4034_/X _4036_/X _4037_/X VGND VGND VPWR VPWR _9044_/D sky130_fd_sc_hd__a22o_1
X_8915_ _8947_/CLK _8915_/D VGND VGND VPWR VPWR _8915_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_24_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8846_ _8942_/CLK _8846_/D VGND VGND VPWR VPWR _8846_/Q sky130_fd_sc_hd__dfxtp_1
X_8777_ _8938_/CLK _8777_/D VGND VGND VPWR VPWR _8777_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5989_ _7045_/X VGND VGND VPWR VPWR _6460_/A sky130_fd_sc_hd__inv_2
XFILLER_12_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7728_ _8273_/Q _8241_/Q _8209_/Q _9009_/Q _7885_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7728_/X sky130_fd_sc_hd__mux4_2
XANTENNA_50 _9083_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7659_ _8110_/Q _8078_/Q _8046_/Q _9038_/Q _7659_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7659_/X sky130_fd_sc_hd__mux4_1
XFILLER_125_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5010_ _8498_/Q _5005_/X _4894_/X _5006_/X VGND VGND VPWR VPWR _8498_/D sky130_fd_sc_hd__a22o_1
Xrepeater115 _7610_/S1 VGND VGND VPWR VPWR _7609_/S1 sky130_fd_sc_hd__buf_8
Xrepeater126 _7990_/S0 VGND VGND VPWR VPWR _8015_/S0 sky130_fd_sc_hd__buf_6
Xrepeater104 _6741_/S VGND VGND VPWR VPWR _6733_/S sky130_fd_sc_hd__buf_4
XFILLER_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xrepeater159 _7391_/S0 VGND VGND VPWR VPWR _7286_/S0 sky130_fd_sc_hd__buf_4
Xrepeater137 _7665_/S0 VGND VGND VPWR VPWR _7689_/S0 sky130_fd_sc_hd__buf_4
XFILLER_66_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater148 _6744_/S VGND VGND VPWR VPWR _6734_/S sky130_fd_sc_hd__buf_8
XFILLER_81_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8700_ _8732_/CLK _8700_/D VGND VGND VPWR VPWR _8700_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_81_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6961_ _6963_/X _6962_/X _6961_/S VGND VGND VPWR VPWR _6961_/X sky130_fd_sc_hd__mux2_1
XFILLER_81_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5912_ _5918_/A _6920_/X VGND VGND VPWR VPWR _6564_/B sky130_fd_sc_hd__or2_1
X_6892_ _6930_/X _6928_/X _6961_/S VGND VGND VPWR VPWR _6892_/X sky130_fd_sc_hd__mux2_1
X_5843_ _6435_/B VGND VGND VPWR VPWR _5946_/A sky130_fd_sc_hd__clkbuf_2
X_8631_ _8729_/CLK _8631_/D VGND VGND VPWR VPWR _8631_/Q sky130_fd_sc_hd__dfxtp_1
X_8562_ _8882_/CLK _8562_/D VGND VGND VPWR VPWR _8562_/Q sky130_fd_sc_hd__dfxtp_1
X_7513_ _8423_/Q _8295_/Q _8359_/Q _8551_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7513_/X sky130_fd_sc_hd__mux4_2
X_5774_ _5822_/A VGND VGND VPWR VPWR _6040_/B sky130_fd_sc_hd__buf_2
X_8493_ _8780_/CLK _8493_/D VGND VGND VPWR VPWR _8493_/Q sky130_fd_sc_hd__dfxtp_1
X_4725_ _4732_/A VGND VGND VPWR VPWR _4725_/X sky130_fd_sc_hd__clkbuf_2
X_4656_ _8708_/Q _4649_/X _4655_/X _4651_/X VGND VGND VPWR VPWR _8708_/D sky130_fd_sc_hd__a22o_1
X_7444_ _8515_/Q _8899_/Q _8835_/Q _8867_/Q _7610_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7444_/X sky130_fd_sc_hd__mux4_2
XFILLER_135_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7375_ _8734_/Q _8702_/Q _8670_/Q _8638_/Q _6343_/A _6344_/B VGND VGND VPWR VPWR
+ _7375_/X sky130_fd_sc_hd__mux4_2
XFILLER_107_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4587_ _4649_/A VGND VGND VPWR VPWR _4613_/A sky130_fd_sc_hd__buf_4
X_6326_ _6326_/A VGND VGND VPWR VPWR _6333_/B sky130_fd_sc_hd__inv_2
XFILLER_103_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6257_ _6257_/A _6305_/A VGND VGND VPWR VPWR _6257_/X sky130_fd_sc_hd__or2_1
X_9045_ _9050_/CLK _9045_/D VGND VGND VPWR VPWR _9045_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_131_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5208_ _6778_/X VGND VGND VPWR VPWR _5208_/X sky130_fd_sc_hd__clkbuf_2
X_6188_ _9072_/Q _6225_/A _6148_/A VGND VGND VPWR VPWR _6191_/B sky130_fd_sc_hd__o21ai_1
X_5139_ _8414_/Q _5133_/X _5138_/X _5136_/X VGND VGND VPWR VPWR _8414_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8829_ _8863_/CLK _8829_/D VGND VGND VPWR VPWR _8829_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_16_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5490_ _8222_/Q _5484_/X _5410_/X _5488_/X VGND VGND VPWR VPWR _8222_/D sky130_fd_sc_hd__a22o_1
XPHY_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4510_ _8788_/Q _4507_/X _4342_/X _4508_/X VGND VGND VPWR VPWR _8788_/D sky130_fd_sc_hd__a22o_1
X_4441_ _4479_/A VGND VGND VPWR VPWR _4458_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_7_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7160_ _8968_/Q _8392_/Q _8168_/Q _8744_/Q _7184_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7160_/X sky130_fd_sc_hd__mux4_1
XFILLER_125_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4372_ _4647_/A VGND VGND VPWR VPWR _4372_/X sky130_fd_sc_hd__clkbuf_2
X_6111_ input7/X VGND VGND VPWR VPWR _6217_/A sky130_fd_sc_hd__inv_2
XFILLER_112_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7091_ _7087_/X _7088_/X _7089_/X _7090_/X _7286_/S0 _7381_/S1 VGND VGND VPWR VPWR
+ _7091_/X sky130_fd_sc_hd__mux4_1
XFILLER_113_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6042_ _6673_/A _6518_/A _6677_/A _6041_/X VGND VGND VPWR VPWR _6059_/A sky130_fd_sc_hd__a22o_1
XFILLER_85_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7993_ _8447_/Q _8319_/Q _8383_/Q _8575_/Q _7995_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7993_/X sky130_fd_sc_hd__mux4_1
XFILLER_82_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6944_ _7069_/X _6976_/X _6974_/S VGND VGND VPWR VPWR _6944_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8614_ _8710_/CLK _8614_/D VGND VGND VPWR VPWR _8614_/Q sky130_fd_sc_hd__dfxtp_1
X_6875_ _5922_/X _6988_/X _6943_/S VGND VGND VPWR VPWR _6875_/X sky130_fd_sc_hd__mux2_1
XFILLER_50_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5826_ _6943_/X _5947_/B _5824_/Y _5825_/X VGND VGND VPWR VPWR _5827_/B sky130_fd_sc_hd__a22o_1
X_5757_ _8043_/Q _5755_/X _4638_/A _5756_/X VGND VGND VPWR VPWR _8043_/D sky130_fd_sc_hd__a22o_1
X_8545_ _8545_/CLK _8545_/D VGND VGND VPWR VPWR _8545_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4708_ _8677_/Q _4705_/X _4653_/X _4706_/X VGND VGND VPWR VPWR _8677_/D sky130_fd_sc_hd__a22o_1
X_8476_ _8731_/CLK _8476_/D VGND VGND VPWR VPWR _8476_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_108_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7427_ _8578_/Q _8130_/Q _8482_/Q _8770_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7427_/X sky130_fd_sc_hd__mux4_1
X_5688_ _8090_/Q _5686_/X _4602_/A _5687_/X VGND VGND VPWR VPWR _8090_/D sky130_fd_sc_hd__a22o_1
XFILLER_135_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4639_ _4651_/A VGND VGND VPWR VPWR _4639_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_104_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7358_ _8284_/Q _8252_/Q _8220_/Q _9020_/Q _7390_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7358_/X sky130_fd_sc_hd__mux4_2
XFILLER_116_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7289_ _8117_/Q _8085_/Q _8053_/Q _9045_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7289_/X sky130_fd_sc_hd__mux4_1
X_6309_ _6309_/A _6309_/B VGND VGND VPWR VPWR _6309_/X sky130_fd_sc_hd__or2_1
X_9028_ _9028_/CLK _9028_/D VGND VGND VPWR VPWR _9028_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_77_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_85_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4990_ _5026_/A VGND VGND VPWR VPWR _5027_/A sky130_fd_sc_hd__inv_2
XFILLER_90_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6660_ _6655_/A _6655_/B _6655_/Y VGND VGND VPWR VPWR _6660_/X sky130_fd_sc_hd__a21o_1
XFILLER_32_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5611_ _5618_/A VGND VGND VPWR VPWR _5611_/X sky130_fd_sc_hd__buf_2
X_6591_ _6481_/A _6590_/X _6481_/A _6590_/X VGND VGND VPWR VPWR _6591_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_129_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8330_ _8907_/CLK _8330_/D VGND VGND VPWR VPWR _8330_/Q sky130_fd_sc_hd__dfxtp_1
X_5542_ _5549_/A VGND VGND VPWR VPWR _5542_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_129_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8261_ _8998_/CLK _8261_/D VGND VGND VPWR VPWR _8261_/Q sky130_fd_sc_hd__dfxtp_1
X_5473_ _8228_/Q _5466_/X _5472_/X _5468_/X VGND VGND VPWR VPWR _8228_/D sky130_fd_sc_hd__a22o_1
X_4424_ _4431_/A VGND VGND VPWR VPWR _4424_/X sky130_fd_sc_hd__clkbuf_2
X_7212_ _8814_/Q _8334_/Q _8942_/Q _8462_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7212_/X sky130_fd_sc_hd__mux4_1
X_8192_ _9024_/CLK _8192_/D VGND VGND VPWR VPWR _8192_/Q sky130_fd_sc_hd__dfxtp_1
X_7143_ _8423_/Q _8295_/Q _8359_/Q _8551_/Q _7185_/S0 _7185_/S1 VGND VGND VPWR VPWR
+ _7143_/X sky130_fd_sc_hd__mux4_1
XFILLER_99_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4355_ _8879_/Q _4350_/X _4354_/X _4352_/X VGND VGND VPWR VPWR _8879_/D sky130_fd_sc_hd__a22o_1
XFILLER_86_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7074_ _8512_/Q _8896_/Q _8832_/Q _8864_/Q _7369_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7074_/X sky130_fd_sc_hd__mux4_1
XFILLER_59_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4286_ _8914_/Q _4281_/X _4043_/X _4282_/X VGND VGND VPWR VPWR _8914_/D sky130_fd_sc_hd__a22o_1
XFILLER_104_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6025_ _6025_/A _6025_/B _6025_/C _6011_/X VGND VGND VPWR VPWR _6028_/A sky130_fd_sc_hd__or4b_4
XFILLER_104_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7976_ _7972_/X _7973_/X _7974_/X _7975_/X _7996_/S0 _5771_/B VGND VGND VPWR VPWR
+ _7976_/X sky130_fd_sc_hd__mux4_2
XFILLER_54_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6927_ _7042_/X _7045_/X _6963_/S VGND VGND VPWR VPWR _6927_/X sky130_fd_sc_hd__mux2_1
XFILLER_23_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6858_ _6859_/X _6559_/B _6918_/S VGND VGND VPWR VPWR _6858_/X sky130_fd_sc_hd__mux2_2
XPHY_1859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5809_ _5808_/Y _5802_/A _6882_/X _5920_/B VGND VGND VPWR VPWR _5810_/A sky130_fd_sc_hd__o22a_1
XFILLER_10_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6789_ _6102_/Y _6119_/X _6809_/S VGND VGND VPWR VPWR _6789_/X sky130_fd_sc_hd__mux2_4
X_8528_ _8943_/CLK _8528_/D VGND VGND VPWR VPWR _8528_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_13_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8459_ _8907_/CLK _8459_/D VGND VGND VPWR VPWR _8459_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_2_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4140_ _9004_/Q _4134_/X _4063_/X _4135_/X VGND VGND VPWR VPWR _9004_/D sky130_fd_sc_hd__a22o_1
X_4071_ _4088_/A VGND VGND VPWR VPWR _4071_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_95_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7830_ _8982_/Q _8406_/Q _8182_/Q _8758_/Q _7909_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7830_/X sky130_fd_sc_hd__mux4_1
XFILLER_91_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4973_ _8523_/Q _4971_/X _4911_/X _4972_/X VGND VGND VPWR VPWR _8523_/D sky130_fd_sc_hd__a22o_1
XFILLER_91_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7761_ _7757_/X _7758_/X _7759_/X _7760_/X _7801_/S0 input17/X VGND VGND VPWR VPWR
+ _7761_/X sky130_fd_sc_hd__mux4_2
X_7692_ _8816_/Q _8336_/Q _8944_/Q _8464_/Q _7697_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7692_/X sky130_fd_sc_hd__mux4_1
X_6712_ _7226_/X _7231_/X _6714_/S VGND VGND VPWR VPWR _6712_/X sky130_fd_sc_hd__mux2_2
X_6643_ _6643_/A VGND VGND VPWR VPWR _6643_/Y sky130_fd_sc_hd__inv_2
XFILLER_118_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6574_ _6436_/X _6571_/X _7009_/X _6572_/X _6573_/Y VGND VGND VPWR VPWR _6574_/Y
+ sky130_fd_sc_hd__o221ai_2
XFILLER_9_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5525_ _8197_/Q _5522_/X _5470_/X _5523_/X VGND VGND VPWR VPWR _8197_/D sky130_fd_sc_hd__a22o_1
X_8313_ _8729_/CLK _8313_/D VGND VGND VPWR VPWR _8313_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_133_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5456_ _5468_/A VGND VGND VPWR VPWR _5456_/X sky130_fd_sc_hd__buf_2
X_8244_ _9012_/CLK _8244_/D VGND VGND VPWR VPWR _8244_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_132_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4407_ _8855_/Q _4402_/X _4334_/X _4403_/X VGND VGND VPWR VPWR _8855_/D sky130_fd_sc_hd__a22o_1
XFILLER_132_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5387_ _5394_/A VGND VGND VPWR VPWR _5387_/X sky130_fd_sc_hd__clkbuf_2
X_8175_ _8975_/CLK _8175_/D VGND VGND VPWR VPWR _8175_/Q sky130_fd_sc_hd__dfxtp_1
X_7126_ _7122_/X _7123_/X _7124_/X _7125_/X input35/X _7191_/S1 VGND VGND VPWR VPWR
+ _7126_/X sky130_fd_sc_hd__mux4_2
XFILLER_101_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4338_ _4338_/A VGND VGND VPWR VPWR _4338_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_101_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4269_ _8927_/Q _4265_/X _4111_/X _4268_/X VGND VGND VPWR VPWR _8927_/D sky130_fd_sc_hd__a22o_1
X_7057_ _6363_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7057_/X sky130_fd_sc_hd__mux2_2
X_6008_ _6008_/A VGND VGND VPWR VPWR _6008_/X sky130_fd_sc_hd__buf_1
XFILLER_54_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7959_ _8125_/Q _8093_/Q _8061_/Q _9053_/Q _8030_/S0 _5772_/B VGND VGND VPWR VPWR
+ _7959_/X sky130_fd_sc_hd__mux4_1
XFILLER_54_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6290_ _6143_/A _6143_/B _9057_/Q _6291_/B VGND VGND VPWR VPWR _6290_/X sky130_fd_sc_hd__o22a_1
X_5310_ _5346_/A VGND VGND VPWR VPWR _5347_/A sky130_fd_sc_hd__clkinv_4
XFILLER_6_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5241_ _8365_/Q _5236_/X _5178_/X _5237_/X VGND VGND VPWR VPWR _8365_/D sky130_fd_sc_hd__a22o_1
X_5172_ _5196_/A VGND VGND VPWR VPWR _5172_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_69_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4123_ _9017_/Q _4120_/X _4019_/X _4121_/X VGND VGND VPWR VPWR _9017_/D sky130_fd_sc_hd__a22o_1
X_8931_ _8932_/CLK _8931_/D VGND VGND VPWR VPWR _8931_/Q sky130_fd_sc_hd__dfxtp_1
X_4054_ _4088_/A VGND VGND VPWR VPWR _4054_/X sky130_fd_sc_hd__buf_2
Xinput2 imData[10] VGND VGND VPWR VPWR input2/X sky130_fd_sc_hd__clkbuf_2
XFILLER_83_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8862_ _8958_/CLK _8862_/D VGND VGND VPWR VPWR _8862_/Q sky130_fd_sc_hd__dfxtp_1
X_8793_ _8794_/CLK _8793_/D VGND VGND VPWR VPWR _8793_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_36_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7813_ _8438_/Q _8310_/Q _8374_/Q _8566_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7813_/X sky130_fd_sc_hd__mux4_1
X_7744_ _8530_/Q _8914_/Q _8850_/Q _8882_/Q _7949_/S0 input9/X VGND VGND VPWR VPWR
+ _7744_/X sky130_fd_sc_hd__mux4_1
XPHY_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4956_ _8534_/Q _4950_/X _4884_/X _4951_/X VGND VGND VPWR VPWR _8534_/D sky130_fd_sc_hd__a22o_1
X_4887_ _6799_/X VGND VGND VPWR VPWR _4887_/X sky130_fd_sc_hd__clkbuf_2
X_7675_ _8719_/Q _8687_/Q _8655_/Q _8623_/Q _7697_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7675_/X sky130_fd_sc_hd__mux4_2
X_6626_ _6511_/B _6615_/X _6511_/B _6615_/X VGND VGND VPWR VPWR _6626_/Y sky130_fd_sc_hd__a2bb2oi_1
X_6557_ _6815_/X _6073_/A _6556_/Y _6073_/Y VGND VGND VPWR VPWR _6557_/X sky130_fd_sc_hd__a22o_1
XFILLER_133_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5508_ _5522_/A VGND VGND VPWR VPWR _5508_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_133_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6488_ _6822_/X VGND VGND VPWR VPWR _6488_/Y sky130_fd_sc_hd__inv_2
X_8227_ _9062_/CLK _8227_/D VGND VGND VPWR VPWR _8227_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_79_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5439_ _8242_/Q _5430_/X _5438_/X _5432_/X VGND VGND VPWR VPWR _8242_/D sky130_fd_sc_hd__a22o_1
XFILLER_126_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8158_ _9053_/CLK _8158_/D VGND VGND VPWR VPWR _8158_/Q sky130_fd_sc_hd__dfxtp_1
X_7109_ _8099_/Q _8067_/Q _8035_/Q _9027_/Q _7140_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7109_/X sky130_fd_sc_hd__mux4_2
XFILLER_101_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8089_ _9080_/CLK _8089_/D VGND VGND VPWR VPWR _8089_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_47_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4810_ _5083_/A _5579_/B VGND VGND VPWR VPWR _4849_/A sky130_fd_sc_hd__or2_4
XFILLER_22_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5790_ _6868_/X VGND VGND VPWR VPWR _5790_/Y sky130_fd_sc_hd__inv_2
X_4741_ _8656_/Q _4739_/X _4626_/X _4740_/X VGND VGND VPWR VPWR _8656_/D sky130_fd_sc_hd__a22o_1
X_4672_ _8703_/Q _4667_/X _4668_/X _4671_/X VGND VGND VPWR VPWR _8703_/D sky130_fd_sc_hd__a22o_1
X_7460_ _8964_/Q _8388_/Q _8164_/Q _8740_/Q _7500_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7460_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6411_ _6410_/X _7040_/X VGND VGND VPWR VPWR _6411_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_128_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7391_ _7387_/X _7388_/X _7389_/X _7390_/X _7391_/S0 _6343_/B VGND VGND VPWR VPWR
+ _7391_/X sky130_fd_sc_hd__mux4_2
XFILLER_115_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6342_ _6340_/X _6341_/X _6340_/X _6341_/X VGND VGND VPWR VPWR _6342_/Y sky130_fd_sc_hd__o2bb2ai_1
XFILLER_115_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9061_ _9061_/CLK _9061_/D repeater146/X VGND VGND VPWR VPWR _9061_/Q sky130_fd_sc_hd__dfrtp_2
X_6273_ _6264_/A _6264_/B _6265_/B VGND VGND VPWR VPWR _6274_/A sky130_fd_sc_hd__a21bo_1
XFILLER_130_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8012_ _8800_/Q _8320_/Q _8928_/Q _8448_/Q _8015_/S0 _5872_/B VGND VGND VPWR VPWR
+ _8012_/X sky130_fd_sc_hd__mux4_2
X_5224_ _8378_/Q _5222_/X _5147_/X _5223_/X VGND VGND VPWR VPWR _8378_/D sky130_fd_sc_hd__a22o_1
XFILLER_111_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5155_ _8407_/Q _5146_/X _5154_/X _5148_/X VGND VGND VPWR VPWR _8407_/D sky130_fd_sc_hd__a22o_1
X_5086_ _5122_/A VGND VGND VPWR VPWR _5123_/A sky130_fd_sc_hd__clkinv_4
X_4106_ _6810_/X _4858_/B _6812_/X VGND VGND VPWR VPWR _5482_/A sky130_fd_sc_hd__or3_4
XFILLER_71_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8914_ _9013_/CLK _8914_/D VGND VGND VPWR VPWR _8914_/Q sky130_fd_sc_hd__dfxtp_1
X_4037_ _4037_/A VGND VGND VPWR VPWR _4037_/X sky130_fd_sc_hd__clkbuf_4
X_8845_ _8877_/CLK _8845_/D VGND VGND VPWR VPWR _8845_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8776_ _9056_/CLK _8776_/D VGND VGND VPWR VPWR _8776_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5988_ _7054_/X _5988_/B VGND VGND VPWR VPWR _5988_/X sky130_fd_sc_hd__or2_1
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4939_ _4978_/A VGND VGND VPWR VPWR _4957_/A sky130_fd_sc_hd__clkbuf_4
X_7727_ _8593_/Q _8145_/Q _8497_/Q _8785_/Q _7885_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7727_/X sky130_fd_sc_hd__mux4_2
XANTENNA_40 _6742_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7658_ _8270_/Q _8238_/Q _8206_/Q _9006_/Q _7700_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7658_/X sky130_fd_sc_hd__mux4_2
XANTENNA_51 _9084_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6609_ _6460_/A _6460_/B _6461_/B VGND VGND VPWR VPWR _6609_/X sky130_fd_sc_hd__a21bo_1
XFILLER_20_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7589_ _8106_/Q _8074_/Q _8042_/Q _9034_/Q _7610_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7589_/X sky130_fd_sc_hd__mux4_1
XFILLER_125_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater116 _7604_/S1 VGND VGND VPWR VPWR _7610_/S1 sky130_fd_sc_hd__buf_8
XFILLER_94_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater105 _6743_/S VGND VGND VPWR VPWR _6735_/S sky130_fd_sc_hd__buf_6
XFILLER_39_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrepeater127 _8005_/S0 VGND VGND VPWR VPWR _7990_/S0 sky130_fd_sc_hd__buf_8
Xrepeater149 _6704_/S VGND VGND VPWR VPWR _6744_/S sky130_fd_sc_hd__buf_8
XFILLER_78_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater138 _7645_/S0 VGND VGND VPWR VPWR _7665_/S0 sky130_fd_sc_hd__buf_8
XFILLER_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6960_ _7033_/X _7036_/X _6963_/S VGND VGND VPWR VPWR _6960_/X sky130_fd_sc_hd__mux2_1
XFILLER_38_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5911_ _5875_/X _6998_/X VGND VGND VPWR VPWR _5911_/Y sky130_fd_sc_hd__nand2b_1
X_6891_ _6927_/X _6924_/X _6961_/S VGND VGND VPWR VPWR _6891_/X sky130_fd_sc_hd__mux2_1
X_5842_ _5842_/A VGND VGND VPWR VPWR _5842_/X sky130_fd_sc_hd__buf_1
XFILLER_21_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8630_ _8822_/CLK _8630_/D VGND VGND VPWR VPWR _8630_/Q sky130_fd_sc_hd__dfxtp_1
X_5773_ _5818_/B VGND VGND VPWR VPWR _5822_/A sky130_fd_sc_hd__buf_2
X_8561_ _8821_/CLK _8561_/D VGND VGND VPWR VPWR _8561_/Q sky130_fd_sc_hd__dfxtp_1
X_4724_ _8667_/Q _4716_/X _4599_/X _4719_/X VGND VGND VPWR VPWR _8667_/D sky130_fd_sc_hd__a22o_1
X_7512_ _8807_/Q _8327_/Q _8935_/Q _8455_/Q _7594_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7512_/X sky130_fd_sc_hd__mux4_1
X_8492_ _8780_/CLK _8492_/D VGND VGND VPWR VPWR _8492_/Q sky130_fd_sc_hd__dfxtp_1
X_7443_ _8419_/Q _8291_/Q _8355_/Q _8547_/Q _7610_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7443_/X sky130_fd_sc_hd__mux4_1
X_4655_ _4655_/A VGND VGND VPWR VPWR _4655_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_128_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7374_ _8542_/Q _8926_/Q _8862_/Q _8894_/Q _7374_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7374_/X sky130_fd_sc_hd__mux4_1
X_4586_ _5083_/A _4762_/B VGND VGND VPWR VPWR _4649_/A sky130_fd_sc_hd__or2_4
XFILLER_1_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6325_ _6329_/A _6324_/A _6178_/A _6324_/Y VGND VGND VPWR VPWR _6326_/A sky130_fd_sc_hd__o22a_1
X_9044_ _9044_/CLK _9044_/D VGND VGND VPWR VPWR _9044_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_107_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6256_ _9065_/Q _6255_/Y _6246_/B VGND VGND VPWR VPWR _6305_/A sky130_fd_sc_hd__o21ai_2
X_5207_ _8385_/Q _5158_/A _5206_/X _5160_/A VGND VGND VPWR VPWR _8385_/D sky130_fd_sc_hd__a22o_1
XFILLER_57_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6187_ _9083_/Q _6165_/B _6166_/A VGND VGND VPWR VPWR _6331_/A sky130_fd_sc_hd__o21ai_2
X_5138_ _6808_/X VGND VGND VPWR VPWR _5138_/X sky130_fd_sc_hd__clkbuf_2
X_5069_ _8459_/Q _5067_/X _4911_/X _5068_/X VGND VGND VPWR VPWR _8459_/D sky130_fd_sc_hd__a22o_1
XFILLER_25_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8828_ _8959_/CLK _8828_/D VGND VGND VPWR VPWR _8828_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_53_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8759_ _8986_/CLK _8759_/D VGND VGND VPWR VPWR _8759_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4440_ _5083_/A _5259_/A VGND VGND VPWR VPWR _4479_/A sky130_fd_sc_hd__or2_4
X_4371_ _8872_/Q _4362_/X _4370_/X _4364_/X VGND VGND VPWR VPWR _8872_/D sky130_fd_sc_hd__a22o_1
X_6110_ _7068_/X _6110_/B _6110_/C VGND VGND VPWR VPWR _6809_/S sky130_fd_sc_hd__and3_4
X_7090_ _8961_/Q _8385_/Q _8161_/Q _8737_/Q _7389_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7090_/X sky130_fd_sc_hd__mux4_1
XFILLER_98_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6041_ _6520_/A VGND VGND VPWR VPWR _6041_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_67_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7992_ _8831_/Q _8351_/Q _8959_/Q _8479_/Q _7995_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7992_/X sky130_fd_sc_hd__mux4_1
XFILLER_93_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6943_ _6088_/X _6976_/X _6943_/S VGND VGND VPWR VPWR _6943_/X sky130_fd_sc_hd__mux2_1
XFILLER_81_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6874_ _6933_/X _6929_/X _6932_/S VGND VGND VPWR VPWR _6874_/X sky130_fd_sc_hd__mux2_1
X_8613_ _8709_/CLK _8613_/D VGND VGND VPWR VPWR _8613_/Q sky130_fd_sc_hd__dfxtp_1
X_5825_ _6943_/X _5820_/A _6943_/X _5820_/A VGND VGND VPWR VPWR _5825_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_10_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5756_ _5763_/A VGND VGND VPWR VPWR _5756_/X sky130_fd_sc_hd__clkbuf_2
X_8544_ _9055_/CLK _8544_/D VGND VGND VPWR VPWR _8544_/Q sky130_fd_sc_hd__dfxtp_1
X_4707_ _8678_/Q _4705_/X _4650_/X _4706_/X VGND VGND VPWR VPWR _8678_/D sky130_fd_sc_hd__a22o_1
X_8475_ _8956_/CLK _8475_/D VGND VGND VPWR VPWR _8475_/Q sky130_fd_sc_hd__dfxtp_1
X_5687_ _5694_/A VGND VGND VPWR VPWR _5687_/X sky130_fd_sc_hd__clkbuf_2
X_7426_ _7422_/X _7423_/X _7424_/X _7425_/X input10/X _6097_/A VGND VGND VPWR VPWR
+ _7426_/X sky130_fd_sc_hd__mux4_2
X_4638_ _4638_/A VGND VGND VPWR VPWR _4638_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_123_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4569_ _4576_/A VGND VGND VPWR VPWR _4569_/X sky130_fd_sc_hd__clkbuf_2
X_7357_ _8604_/Q _8156_/Q _8508_/Q _8796_/Q _7390_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7357_/X sky130_fd_sc_hd__mux4_1
X_6308_ _6308_/A _6308_/B _6398_/A _6396_/A VGND VGND VPWR VPWR _6309_/B sky130_fd_sc_hd__or4_4
X_7288_ _8277_/Q _8245_/Q _8213_/Q _9013_/Q _7288_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7288_/X sky130_fd_sc_hd__mux4_2
XFILLER_131_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9027_ _9027_/CLK _9027_/D VGND VGND VPWR VPWR _9027_/Q sky130_fd_sc_hd__dfxtp_1
X_6239_ input5/X _6236_/Y _6238_/X VGND VGND VPWR VPWR _6388_/A sky130_fd_sc_hd__o21ai_2
XFILLER_134_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5610_ _8140_/Q _5604_/X _5452_/X _5605_/X VGND VGND VPWR VPWR _8140_/D sky130_fd_sc_hd__a22o_1
X_6590_ _6477_/Y _5974_/A _6481_/B _6589_/X VGND VGND VPWR VPWR _6590_/X sky130_fd_sc_hd__o22a_1
XFILLER_31_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5541_ _8187_/Q _5533_/X _5416_/X _5536_/X VGND VGND VPWR VPWR _8187_/D sky130_fd_sc_hd__a22o_1
XFILLER_31_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8260_ _9027_/CLK _8260_/D VGND VGND VPWR VPWR _8260_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_129_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5472_ _6782_/X VGND VGND VPWR VPWR _5472_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_117_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7211_ _7207_/X _7208_/X _7209_/X _7210_/X _7241_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7211_/X sky130_fd_sc_hd__mux4_2
XFILLER_99_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4423_ _4430_/A VGND VGND VPWR VPWR _4423_/X sky130_fd_sc_hd__clkbuf_2
X_8191_ _9052_/CLK _8191_/D VGND VGND VPWR VPWR _8191_/Q sky130_fd_sc_hd__dfxtp_1
X_7142_ _8807_/Q _8327_/Q _8935_/Q _8455_/Q _7184_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7142_/X sky130_fd_sc_hd__mux4_1
XFILLER_98_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4354_ _4629_/A VGND VGND VPWR VPWR _4354_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_101_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7073_ _8416_/Q _8288_/Q _8352_/Q _8544_/Q _7369_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7073_/X sky130_fd_sc_hd__mux4_1
XFILLER_59_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4285_ _8915_/Q _4281_/X _4040_/X _4282_/X VGND VGND VPWR VPWR _8915_/D sky130_fd_sc_hd__a22o_1
X_6024_ _6024_/A VGND VGND VPWR VPWR _6025_/B sky130_fd_sc_hd__inv_2
XFILLER_104_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7975_ _8734_/Q _8702_/Q _8670_/Q _8638_/Q _7975_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7975_/X sky130_fd_sc_hd__mux4_2
XFILLER_54_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6926_ _6928_/X _6927_/X _6961_/S VGND VGND VPWR VPWR _6926_/X sky130_fd_sc_hd__mux2_1
XFILLER_42_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6857_ _6856_/X _6858_/X _6948_/S VGND VGND VPWR VPWR _6857_/X sky130_fd_sc_hd__mux2_1
XFILLER_50_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5808_ _6882_/X VGND VGND VPWR VPWR _5808_/Y sky130_fd_sc_hd__inv_2
X_6788_ _5850_/Y _5838_/X _6809_/S VGND VGND VPWR VPWR _6788_/X sky130_fd_sc_hd__mux2_4
XFILLER_50_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8527_ _8942_/CLK _8527_/D VGND VGND VPWR VPWR _8527_/Q sky130_fd_sc_hd__dfxtp_1
X_5739_ _8055_/Q _5734_/X _4609_/A _5735_/X VGND VGND VPWR VPWR _8055_/D sky130_fd_sc_hd__a22o_1
XFILLER_136_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8458_ _8907_/CLK _8458_/D VGND VGND VPWR VPWR _8458_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_123_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8389_ _8998_/CLK _8389_/D VGND VGND VPWR VPWR _8389_/Q sky130_fd_sc_hd__dfxtp_1
X_7409_ _8097_/Q _8065_/Q _8033_/Q _9025_/Q _7990_/S0 _5872_/B VGND VGND VPWR VPWR
+ _7409_/X sky130_fd_sc_hd__mux4_1
XFILLER_2_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4070_ _4641_/A VGND VGND VPWR VPWR _4070_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_68_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4972_ _4979_/A VGND VGND VPWR VPWR _4972_/X sky130_fd_sc_hd__clkbuf_2
X_7760_ _8979_/Q _8403_/Q _8179_/Q _8755_/Q _7798_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7760_/X sky130_fd_sc_hd__mux4_1
XFILLER_36_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6711_ _6710_/X _9070_/Q _6743_/S VGND VGND VPWR VPWR _6711_/X sky130_fd_sc_hd__mux2_1
XFILLER_32_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7691_ _7687_/X _7688_/X _7689_/X _7690_/X _7711_/S0 input11/X VGND VGND VPWR VPWR
+ _7691_/X sky130_fd_sc_hd__mux4_1
XFILLER_32_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6642_ _6493_/Y _6017_/A _6501_/B _6637_/Y VGND VGND VPWR VPWR _6643_/A sky130_fd_sc_hd__o22a_1
XFILLER_32_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8312_ _8954_/CLK _8312_/D VGND VGND VPWR VPWR _8312_/Q sky130_fd_sc_hd__dfxtp_1
X_6573_ _6464_/A _5970_/Y _6438_/X VGND VGND VPWR VPWR _6573_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_118_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5524_ _8198_/Q _5522_/X _5467_/X _5523_/X VGND VGND VPWR VPWR _8198_/D sky130_fd_sc_hd__a22o_1
X_5455_ _6789_/X VGND VGND VPWR VPWR _5455_/X sky130_fd_sc_hd__clkbuf_2
X_8243_ _8403_/CLK _8243_/D VGND VGND VPWR VPWR _8243_/Q sky130_fd_sc_hd__dfxtp_1
X_8174_ _9067_/CLK _8174_/D VGND VGND VPWR VPWR _8174_/Q sky130_fd_sc_hd__dfxtp_1
X_4406_ _8856_/Q _4402_/X _4332_/X _4403_/X VGND VGND VPWR VPWR _8856_/D sky130_fd_sc_hd__a22o_1
X_7125_ _8709_/Q _8677_/Q _8645_/Q _8613_/Q _7135_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7125_/X sky130_fd_sc_hd__mux4_1
X_5386_ _8268_/Q _5380_/X _5180_/X _5381_/X VGND VGND VPWR VPWR _8268_/D sky130_fd_sc_hd__a22o_1
XFILLER_87_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4337_ _8886_/Q _4326_/X _4336_/X _4328_/X VGND VGND VPWR VPWR _8886_/D sky130_fd_sc_hd__a22o_1
XFILLER_115_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4268_ _4282_/A VGND VGND VPWR VPWR _4268_/X sky130_fd_sc_hd__clkbuf_2
X_7056_ _7936_/X _7941_/X _7071_/S VGND VGND VPWR VPWR _7056_/X sky130_fd_sc_hd__mux2_2
XFILLER_74_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6007_ _6007_/A VGND VGND VPWR VPWR _6008_/A sky130_fd_sc_hd__inv_2
X_4199_ _4199_/A VGND VGND VPWR VPWR _4199_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_95_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7958_ _8285_/Q _8253_/Q _8221_/Q _9021_/Q _8030_/S0 _5772_/B VGND VGND VPWR VPWR
+ _7958_/X sky130_fd_sc_hd__mux4_1
XFILLER_55_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6909_ _6966_/X _6963_/X _6971_/S VGND VGND VPWR VPWR _6909_/X sky130_fd_sc_hd__mux2_1
X_7889_ _8121_/Q _8089_/Q _8057_/Q _9049_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7889_/X sky130_fd_sc_hd__mux4_2
XPHY_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5240_ _8366_/Q _5236_/X _5176_/X _5237_/X VGND VGND VPWR VPWR _8366_/D sky130_fd_sc_hd__a22o_1
XFILLER_6_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5171_ _6794_/X VGND VGND VPWR VPWR _5171_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_122_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4122_ _9018_/Q _4120_/X _4015_/X _4121_/X VGND VGND VPWR VPWR _9018_/D sky130_fd_sc_hd__a22o_1
X_8930_ _8933_/CLK _8930_/D VGND VGND VPWR VPWR _8930_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_84_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4053_ _4629_/A VGND VGND VPWR VPWR _4053_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_77_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput3 imData[11] VGND VGND VPWR VPWR input3/X sky130_fd_sc_hd__buf_2
XFILLER_37_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8861_ _8958_/CLK _8861_/D VGND VGND VPWR VPWR _8861_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_92_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8792_ _9014_/CLK _8792_/D VGND VGND VPWR VPWR _8792_/Q sky130_fd_sc_hd__dfxtp_1
X_7812_ _8822_/Q _8342_/Q _8950_/Q _8470_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7812_/X sky130_fd_sc_hd__mux4_1
X_7743_ _8434_/Q _8306_/Q _8370_/Q _8562_/Q _7949_/S0 input9/X VGND VGND VPWR VPWR
+ _7743_/X sky130_fd_sc_hd__mux4_2
XFILLER_52_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4955_ _8535_/Q _4950_/X _4882_/X _4951_/X VGND VGND VPWR VPWR _8535_/D sky130_fd_sc_hd__a22o_1
XFILLER_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4886_ _4886_/A VGND VGND VPWR VPWR _4886_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_32_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7674_ _8527_/Q _8911_/Q _8847_/Q _8879_/Q _7697_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7674_/X sky130_fd_sc_hd__mux4_1
XFILLER_20_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6625_ _6512_/A _6616_/X _6512_/A _6616_/X VGND VGND VPWR VPWR _6625_/Y sky130_fd_sc_hd__a2bb2oi_1
X_6556_ _6815_/X VGND VGND VPWR VPWR _6556_/Y sky130_fd_sc_hd__inv_2
XFILLER_20_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5507_ _8209_/Q _5501_/X _5440_/X _5502_/X VGND VGND VPWR VPWR _8209_/D sky130_fd_sc_hd__a22o_1
XFILLER_3_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8226_ _8994_/CLK _8226_/D VGND VGND VPWR VPWR _8226_/Q sky130_fd_sc_hd__dfxtp_1
X_6487_ _6487_/A VGND VGND VPWR VPWR _6550_/A sky130_fd_sc_hd__inv_2
X_5438_ _6796_/X VGND VGND VPWR VPWR _5438_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_102_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8157_ _9052_/CLK _8157_/D VGND VGND VPWR VPWR _8157_/Q sky130_fd_sc_hd__dfxtp_1
X_5369_ _8281_/Q _5366_/X _5150_/X _5367_/X VGND VGND VPWR VPWR _8281_/D sky130_fd_sc_hd__a22o_1
XFILLER_120_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7108_ _8259_/Q _8227_/Q _8195_/Q _8995_/Q _7140_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7108_/X sky130_fd_sc_hd__mux4_2
XFILLER_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8088_ _9048_/CLK _8088_/D VGND VGND VPWR VPWR _8088_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_87_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7039_ _6411_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7039_/X sky130_fd_sc_hd__mux2_2
XFILLER_74_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_116_clk clkbuf_4_0_0_clk/X VGND VGND VPWR VPWR _9012_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_23_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4740_ _4754_/A VGND VGND VPWR VPWR _4740_/X sky130_fd_sc_hd__buf_2
Xclkbuf_leaf_107_clk clkbuf_4_2_0_clk/X VGND VGND VPWR VPWR _8952_/CLK sky130_fd_sc_hd__clkbuf_16
X_4671_ _4685_/A VGND VGND VPWR VPWR _4671_/X sky130_fd_sc_hd__clkbuf_2
X_7390_ _8991_/Q _8415_/Q _8191_/Q _8767_/Q _7390_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7390_/X sky130_fd_sc_hd__mux4_1
X_6410_ _6604_/A VGND VGND VPWR VPWR _6410_/X sky130_fd_sc_hd__buf_1
XFILLER_127_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6341_ _6114_/X _6173_/A _6178_/X _6173_/Y VGND VGND VPWR VPWR _6341_/X sky130_fd_sc_hd__o22a_1
XFILLER_127_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_9060_ _9061_/CLK _9060_/D repeater146/X VGND VGND VPWR VPWR _9060_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_89_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6272_ _5931_/Y _6271_/A _6974_/S _6271_/Y VGND VGND VPWR VPWR _6401_/A sky130_fd_sc_hd__o22a_1
XFILLER_6_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8011_ _8007_/X _8008_/X _8009_/X _8010_/X _8011_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _8011_/X sky130_fd_sc_hd__mux4_1
X_5223_ _5230_/A VGND VGND VPWR VPWR _5223_/X sky130_fd_sc_hd__clkbuf_2
X_5154_ _6801_/X VGND VGND VPWR VPWR _5154_/X sky130_fd_sc_hd__clkbuf_2
X_4105_ _6811_/X VGND VGND VPWR VPWR _4858_/B sky130_fd_sc_hd__inv_2
X_5085_ _5101_/A VGND VGND VPWR VPWR _5085_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_96_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4036_ _4617_/A VGND VGND VPWR VPWR _4036_/X sky130_fd_sc_hd__clkbuf_2
X_8913_ _8945_/CLK _8913_/D VGND VGND VPWR VPWR _8913_/Q sky130_fd_sc_hd__dfxtp_1
X_8844_ _8876_/CLK _8844_/D VGND VGND VPWR VPWR _8844_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_71_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8775_ _8999_/CLK _8775_/D VGND VGND VPWR VPWR _8775_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5987_ _7048_/X _6482_/A _7045_/X _5986_/Y VGND VGND VPWR VPWR _5992_/B sky130_fd_sc_hd__o22a_1
XFILLER_40_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4938_ _5083_/A _4938_/B VGND VGND VPWR VPWR _4978_/A sky130_fd_sc_hd__or2_4
X_7726_ _7722_/X _7723_/X _7724_/X _7725_/X _7811_/S0 _8021_/S1 VGND VGND VPWR VPWR
+ _7726_/X sky130_fd_sc_hd__mux4_1
X_4869_ _8573_/Q _4861_/X _4868_/X _4864_/X VGND VGND VPWR VPWR _8573_/D sky130_fd_sc_hd__a22o_1
XANTENNA_41 _9068_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7657_ _8590_/Q _8142_/Q _8494_/Q _8782_/Q _7659_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7657_/X sky130_fd_sc_hd__mux4_2
XFILLER_20_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_30 _6528_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_52 _9087_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6608_ _6858_/X _6584_/X _6994_/X _6606_/X _6607_/Y VGND VGND VPWR VPWR _6608_/Y
+ sky130_fd_sc_hd__o221ai_2
X_7588_ _8266_/Q _8234_/Q _8202_/Q _9002_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7588_/X sky130_fd_sc_hd__mux4_1
XFILLER_106_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6539_ _6828_/X _6017_/Y _6491_/X _6827_/X _6002_/X VGND VGND VPWR VPWR _6539_/X
+ sky130_fd_sc_hd__a32o_1
XFILLER_133_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8209_ _9009_/CLK _8209_/D VGND VGND VPWR VPWR _8209_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_87_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xrepeater106 _6705_/S VGND VGND VPWR VPWR _6743_/S sky130_fd_sc_hd__buf_4
Xrepeater117 _7985_/S1 VGND VGND VPWR VPWR _7604_/S1 sky130_fd_sc_hd__buf_6
Xrepeater128 _8005_/S0 VGND VGND VPWR VPWR _8010_/S0 sky130_fd_sc_hd__buf_8
Xrepeater139 _7505_/S0 VGND VGND VPWR VPWR _7645_/S0 sky130_fd_sc_hd__buf_8
XFILLER_93_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5910_ _5900_/A _5864_/B _5870_/D VGND VGND VPWR VPWR _5910_/X sky130_fd_sc_hd__a21bo_1
XFILLER_53_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6890_ _6892_/X _6891_/X _6932_/S VGND VGND VPWR VPWR _6890_/X sky130_fd_sc_hd__mux2_1
X_5841_ _6903_/X _6433_/A VGND VGND VPWR VPWR _5842_/A sky130_fd_sc_hd__or2_1
X_5772_ _7071_/S _5772_/B _5772_/C VGND VGND VPWR VPWR _5818_/B sky130_fd_sc_hd__or3_4
XFILLER_61_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8560_ _8816_/CLK _8560_/D VGND VGND VPWR VPWR _8560_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4723_ _8668_/Q _4716_/X _4597_/X _4719_/X VGND VGND VPWR VPWR _8668_/D sky130_fd_sc_hd__a22o_1
X_8491_ _9033_/CLK _8491_/D VGND VGND VPWR VPWR _8491_/Q sky130_fd_sc_hd__dfxtp_1
X_7511_ _7507_/X _7508_/X _7509_/X _7510_/X input10/X _6097_/A VGND VGND VPWR VPWR
+ _7511_/X sky130_fd_sc_hd__mux4_1
XFILLER_21_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7442_ _8803_/Q _8323_/Q _8931_/Q _8451_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7442_/X sky130_fd_sc_hd__mux4_1
X_4654_ _8709_/Q _4649_/X _4653_/X _4651_/X VGND VGND VPWR VPWR _8709_/D sky130_fd_sc_hd__a22o_1
XFILLER_128_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7373_ _8446_/Q _8318_/Q _8382_/Q _8574_/Q _7374_/S0 _6344_/B VGND VGND VPWR VPWR
+ _7373_/X sky130_fd_sc_hd__mux4_2
X_4585_ _4858_/A _6811_/X _6812_/X VGND VGND VPWR VPWR _4762_/B sky130_fd_sc_hd__or3_4
X_6324_ _6324_/A VGND VGND VPWR VPWR _6324_/Y sky130_fd_sc_hd__inv_2
XFILLER_130_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6255_ _6255_/A _6255_/B VGND VGND VPWR VPWR _6255_/Y sky130_fd_sc_hd__nor2_4
X_9043_ _9044_/CLK _9043_/D VGND VGND VPWR VPWR _9043_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_115_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5206_ _6779_/X VGND VGND VPWR VPWR _5206_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_97_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6186_ _6178_/X _6184_/Y _6185_/X VGND VGND VPWR VPWR _6186_/Y sky130_fd_sc_hd__o21ai_2
X_5137_ _8415_/Q _5133_/X _4941_/X _5136_/X VGND VGND VPWR VPWR _8415_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5068_ _5075_/A VGND VGND VPWR VPWR _5068_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_72_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4019_ _4605_/A VGND VGND VPWR VPWR _4019_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_38_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8827_ _8956_/CLK _8827_/D VGND VGND VPWR VPWR _8827_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_13_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8758_ _8790_/CLK _8758_/D VGND VGND VPWR VPWR _8758_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_139_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7709_ _8112_/Q _8080_/Q _8048_/Q _9040_/Q _7909_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7709_/X sky130_fd_sc_hd__mux4_1
X_8689_ _9051_/CLK _8689_/D VGND VGND VPWR VPWR _8689_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4370_ _4645_/A VGND VGND VPWR VPWR _4370_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_112_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6040_ _7008_/X _6040_/B VGND VGND VPWR VPWR _6520_/A sky130_fd_sc_hd__nand2_1
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7991_ _7987_/X _7988_/X _7989_/X _7990_/X _8011_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _7991_/X sky130_fd_sc_hd__mux4_1
XFILLER_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6942_ _6982_/X _6985_/X _6963_/S VGND VGND VPWR VPWR _6942_/X sky130_fd_sc_hd__mux2_1
X_6873_ _6926_/X _6922_/X _6932_/S VGND VGND VPWR VPWR _6873_/X sky130_fd_sc_hd__mux2_1
X_8612_ _8710_/CLK _8612_/D VGND VGND VPWR VPWR _8612_/Q sky130_fd_sc_hd__dfxtp_1
X_5824_ _5821_/Y _5822_/Y _5858_/B VGND VGND VPWR VPWR _5824_/Y sky130_fd_sc_hd__o21ai_2
XFILLER_62_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5755_ _5762_/A VGND VGND VPWR VPWR _5755_/X sky130_fd_sc_hd__clkbuf_2
X_8543_ _8959_/CLK _8543_/D VGND VGND VPWR VPWR _8543_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4706_ _4706_/A VGND VGND VPWR VPWR _4706_/X sky130_fd_sc_hd__clkbuf_2
X_8474_ _8954_/CLK _8474_/D VGND VGND VPWR VPWR _8474_/Q sky130_fd_sc_hd__dfxtp_1
X_5686_ _5693_/A VGND VGND VPWR VPWR _5686_/X sky130_fd_sc_hd__clkbuf_2
X_7425_ _8706_/Q _8674_/Q _8642_/Q _8610_/Q _7505_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7425_/X sky130_fd_sc_hd__mux4_2
X_4637_ _4649_/A VGND VGND VPWR VPWR _4637_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_108_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7356_ _7352_/X _7353_/X _7354_/X _7355_/X _6343_/C _6343_/B VGND VGND VPWR VPWR
+ _7356_/X sky130_fd_sc_hd__mux4_2
X_4568_ _8748_/Q _4562_/X _4360_/X _4563_/X VGND VGND VPWR VPWR _8748_/D sky130_fd_sc_hd__a22o_1
XFILLER_1_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4499_ _8795_/Q _4491_/X _4324_/X _4494_/X VGND VGND VPWR VPWR _8795_/D sky130_fd_sc_hd__a22o_1
X_6307_ _6932_/S _6259_/B _6259_/Y VGND VGND VPWR VPWR _6396_/A sky130_fd_sc_hd__o21ai_4
XFILLER_1_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7287_ _8597_/Q _8149_/Q _8501_/Q _8789_/Q _7288_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7287_/X sky130_fd_sc_hd__mux4_2
XFILLER_89_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9026_ _9029_/CLK _9026_/D VGND VGND VPWR VPWR _9026_/Q sky130_fd_sc_hd__dfxtp_1
X_6238_ _6238_/A _6238_/B VGND VGND VPWR VPWR _6238_/X sky130_fd_sc_hd__or2_1
XFILLER_131_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6169_ _9085_/Q _6169_/B VGND VGND VPWR VPWR _6170_/A sky130_fd_sc_hd__nand2_1
XFILLER_57_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_96_clk clkbuf_4_8_0_clk/X VGND VGND VPWR VPWR _8986_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_85_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_20_clk clkbuf_4_4_0_clk/X VGND VGND VPWR VPWR _9052_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_139_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_87_clk clkbuf_4_8_0_clk/X VGND VGND VPWR VPWR _9087_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_84_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5540_ _8188_/Q _5533_/X _5414_/X _5536_/X VGND VGND VPWR VPWR _8188_/D sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_11_clk _8032_/CLK VGND VGND VPWR VPWR _9024_/CLK sky130_fd_sc_hd__clkbuf_16
XPHY_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5471_ _8229_/Q _5466_/X _5470_/X _5468_/X VGND VGND VPWR VPWR _8229_/D sky130_fd_sc_hd__a22o_1
X_4422_ _8844_/Q _4416_/X _4360_/X _4417_/X VGND VGND VPWR VPWR _8844_/D sky130_fd_sc_hd__a22o_1
X_7210_ _8973_/Q _8397_/Q _8173_/Q _8749_/Q _7229_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7210_/X sky130_fd_sc_hd__mux4_1
X_8190_ _9053_/CLK _8190_/D VGND VGND VPWR VPWR _8190_/Q sky130_fd_sc_hd__dfxtp_1
X_7141_ _7137_/X _7138_/X _7139_/X _7140_/X input35/X _7191_/S1 VGND VGND VPWR VPWR
+ _7141_/X sky130_fd_sc_hd__mux4_1
X_4353_ _8880_/Q _4350_/X _4351_/X _4352_/X VGND VGND VPWR VPWR _8880_/D sky130_fd_sc_hd__a22o_1
X_7072_ _8800_/Q _8320_/Q _8928_/Q _8448_/Q _7369_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7072_/X sky130_fd_sc_hd__mux4_1
X_4284_ _8916_/Q _4281_/X _4036_/X _4282_/X VGND VGND VPWR VPWR _8916_/D sky130_fd_sc_hd__a22o_1
XFILLER_99_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6023_ _6025_/A _6021_/X _6024_/A VGND VGND VPWR VPWR _6023_/X sky130_fd_sc_hd__o21a_1
Xclkbuf_leaf_78_clk clkbuf_4_11_0_clk/X VGND VGND VPWR VPWR _8782_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_39_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7974_ _8542_/Q _8926_/Q _8862_/Q _8894_/Q _7975_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7974_/X sky130_fd_sc_hd__mux4_2
XFILLER_82_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6925_ _6929_/X _6926_/X _6932_/S VGND VGND VPWR VPWR _6925_/X sky130_fd_sc_hd__mux2_1
XFILLER_120_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6856_ _6855_/X _6860_/X _6918_/S VGND VGND VPWR VPWR _6856_/X sky130_fd_sc_hd__mux2_1
XFILLER_50_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5807_ _5807_/A VGND VGND VPWR VPWR _5832_/A sky130_fd_sc_hd__inv_2
X_6787_ _5883_/Y _5879_/Y _6809_/S VGND VGND VPWR VPWR _6787_/X sky130_fd_sc_hd__mux2_4
X_3999_ _6808_/X VGND VGND VPWR VPWR _4593_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_22_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8526_ _8877_/CLK _8526_/D VGND VGND VPWR VPWR _8526_/Q sky130_fd_sc_hd__dfxtp_1
X_5738_ _8056_/Q _5734_/X _4607_/A _5735_/X VGND VGND VPWR VPWR _8056_/D sky130_fd_sc_hd__a22o_1
XFILLER_108_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8457_ _8841_/CLK _8457_/D VGND VGND VPWR VPWR _8457_/Q sky130_fd_sc_hd__dfxtp_1
X_5669_ _8101_/Q _5666_/X _5470_/X _5667_/X VGND VGND VPWR VPWR _8101_/D sky130_fd_sc_hd__a22o_1
X_8388_ _9027_/CLK _8388_/D VGND VGND VPWR VPWR _8388_/Q sky130_fd_sc_hd__dfxtp_1
X_7408_ _8257_/Q _8225_/Q _8193_/Q _8993_/Q _7990_/S0 _5872_/B VGND VGND VPWR VPWR
+ _7408_/X sky130_fd_sc_hd__mux4_2
XFILLER_2_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7339_ _8122_/Q _8090_/Q _8058_/Q _9050_/Q _7339_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7339_/X sky130_fd_sc_hd__mux4_1
XFILLER_104_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9009_ _9009_/CLK _9009_/D VGND VGND VPWR VPWR _9009_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_131_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_69_clk clkbuf_4_14_0_clk/X VGND VGND VPWR VPWR _9028_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_77_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_0_clk clkbuf_4_0_0_clk/X VGND VGND VPWR VPWR _8787_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_64_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4971_ _4978_/A VGND VGND VPWR VPWR _4971_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_51_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6710_ _7216_/X _7221_/X _6714_/S VGND VGND VPWR VPWR _6710_/X sky130_fd_sc_hd__mux2_1
X_7690_ _8975_/Q _8399_/Q _8175_/Q _8751_/Q _7710_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7690_/X sky130_fd_sc_hd__mux4_1
X_6641_ _6456_/A _6456_/B _6457_/B VGND VGND VPWR VPWR _6641_/X sky130_fd_sc_hd__a21bo_1
XFILLER_20_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6572_ _6572_/A VGND VGND VPWR VPWR _6572_/X sky130_fd_sc_hd__clkbuf_2
X_8311_ _8665_/CLK _8311_/D VGND VGND VPWR VPWR _8311_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_118_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5523_ _5523_/A VGND VGND VPWR VPWR _5523_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_118_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5454_ _5466_/A VGND VGND VPWR VPWR _5454_/X sky130_fd_sc_hd__buf_2
X_8242_ _8787_/CLK _8242_/D VGND VGND VPWR VPWR _8242_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5385_ _8269_/Q _5380_/X _5178_/X _5381_/X VGND VGND VPWR VPWR _8269_/D sky130_fd_sc_hd__a22o_1
X_8173_ _9037_/CLK _8173_/D VGND VGND VPWR VPWR _8173_/Q sky130_fd_sc_hd__dfxtp_1
X_4405_ _8857_/Q _4402_/X _4330_/X _4403_/X VGND VGND VPWR VPWR _8857_/D sky130_fd_sc_hd__a22o_1
X_7124_ _8517_/Q _8901_/Q _8837_/Q _8869_/Q _7135_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7124_/X sky130_fd_sc_hd__mux4_1
X_4336_ _4611_/A VGND VGND VPWR VPWR _4336_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_115_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4267_ _4303_/A VGND VGND VPWR VPWR _4282_/A sky130_fd_sc_hd__clkbuf_4
X_7055_ _7926_/X _7931_/X _7067_/S VGND VGND VPWR VPWR _7055_/X sky130_fd_sc_hd__mux2_2
X_4198_ _8967_/Q _4192_/X _4080_/X _4193_/X VGND VGND VPWR VPWR _8967_/D sky130_fd_sc_hd__a22o_1
XFILLER_101_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6006_ _7023_/X _6037_/B VGND VGND VPWR VPWR _6007_/A sky130_fd_sc_hd__nand2_1
XFILLER_67_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7957_ _8605_/Q _8157_/Q _8509_/Q _8797_/Q _8025_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7957_/X sky130_fd_sc_hd__mux4_2
XFILLER_42_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6908_ _6910_/X _6909_/X _6964_/S VGND VGND VPWR VPWR _6908_/X sky130_fd_sc_hd__mux2_1
X_7888_ _8281_/Q _8249_/Q _8217_/Q _9017_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7888_/X sky130_fd_sc_hd__mux4_1
XPHY_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6839_ _6679_/Y _7012_/X _6943_/S VGND VGND VPWR VPWR _6839_/X sky130_fd_sc_hd__mux2_2
XPHY_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8509_ _8989_/CLK _8509_/D VGND VGND VPWR VPWR _8509_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_136_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5170_ _5194_/A VGND VGND VPWR VPWR _5170_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_122_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4121_ _4128_/A VGND VGND VPWR VPWR _4121_/X sky130_fd_sc_hd__clkbuf_2
X_4052_ _6793_/X VGND VGND VPWR VPWR _4629_/A sky130_fd_sc_hd__clkbuf_2
Xinput4 imData[12] VGND VGND VPWR VPWR input4/X sky130_fd_sc_hd__buf_4
XFILLER_110_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8860_ _8959_/CLK _8860_/D VGND VGND VPWR VPWR _8860_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_51_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8791_ _8794_/CLK _8791_/D VGND VGND VPWR VPWR _8791_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_24_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7811_ _7807_/X _7808_/X _7809_/X _7810_/X _7811_/S0 _8021_/S1 VGND VGND VPWR VPWR
+ _7811_/X sky130_fd_sc_hd__mux4_2
X_7742_ _8818_/Q _8338_/Q _8946_/Q _8466_/Q _7949_/S0 input9/X VGND VGND VPWR VPWR
+ _7742_/X sky130_fd_sc_hd__mux4_1
X_4954_ _8536_/Q _4950_/X _4880_/X _4951_/X VGND VGND VPWR VPWR _8536_/D sky130_fd_sc_hd__a22o_1
XFILLER_60_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4885_ _8566_/Q _4874_/X _4884_/X _4876_/X VGND VGND VPWR VPWR _8566_/D sky130_fd_sc_hd__a22o_1
X_7673_ _8431_/Q _8303_/Q _8367_/Q _8559_/Q _7697_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7673_/X sky130_fd_sc_hd__mux4_1
XFILLER_137_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6624_ _6612_/A _6612_/B _6612_/Y VGND VGND VPWR VPWR _6624_/X sky130_fd_sc_hd__a21o_1
X_6555_ _6469_/Y _5963_/A _6470_/X _6554_/X VGND VGND VPWR VPWR _6555_/X sky130_fd_sc_hd__o22a_1
XFILLER_20_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5506_ _8210_/Q _5501_/X _5438_/X _5502_/X VGND VGND VPWR VPWR _8210_/D sky130_fd_sc_hd__a22o_1
XFILLER_105_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8225_ _9054_/CLK _8225_/D VGND VGND VPWR VPWR _8225_/Q sky130_fd_sc_hd__dfxtp_1
X_6486_ _6821_/X _6482_/X _6821_/X _6482_/X VGND VGND VPWR VPWR _6487_/A sky130_fd_sc_hd__o2bb2a_1
XFILLER_133_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5437_ _8243_/Q _5430_/X _5436_/X _5432_/X VGND VGND VPWR VPWR _8243_/D sky130_fd_sc_hd__a22o_1
XFILLER_120_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8156_ _9020_/CLK _8156_/D VGND VGND VPWR VPWR _8156_/Q sky130_fd_sc_hd__dfxtp_1
X_5368_ _8282_/Q _5366_/X _5147_/X _5367_/X VGND VGND VPWR VPWR _8282_/D sky130_fd_sc_hd__a22o_1
X_5299_ _5299_/A VGND VGND VPWR VPWR _5299_/X sky130_fd_sc_hd__buf_2
X_7107_ _8579_/Q _8131_/Q _8483_/Q _8771_/Q _7140_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7107_/X sky130_fd_sc_hd__mux4_1
X_4319_ _8894_/Q _4313_/X _4318_/X _4316_/X VGND VGND VPWR VPWR _8894_/D sky130_fd_sc_hd__a22o_1
X_8087_ _9080_/CLK _8087_/D VGND VGND VPWR VPWR _8087_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_101_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7038_ _7816_/X _7821_/X _7059_/S VGND VGND VPWR VPWR _7038_/X sky130_fd_sc_hd__mux2_1
XFILLER_101_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8989_ _8989_/CLK _8989_/D VGND VGND VPWR VPWR _8989_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_55_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4670_ _4706_/A VGND VGND VPWR VPWR _4685_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_119_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6340_ _6114_/X _6338_/A _6337_/X _6339_/X VGND VGND VPWR VPWR _6340_/X sky130_fd_sc_hd__o22a_1
XFILLER_128_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6271_ _6271_/A VGND VGND VPWR VPWR _6271_/Y sky130_fd_sc_hd__inv_2
XFILLER_102_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8010_ _8991_/Q _8415_/Q _8191_/Q _8767_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _8010_/X sky130_fd_sc_hd__mux4_1
X_5222_ _5229_/A VGND VGND VPWR VPWR _5222_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_123_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5153_ _8408_/Q _5146_/X _5152_/X _5148_/X VGND VGND VPWR VPWR _8408_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4104_ _9024_/Q _4034_/A _4103_/X _4037_/A VGND VGND VPWR VPWR _9024_/D sky130_fd_sc_hd__a22o_1
XFILLER_29_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5084_ _5122_/A VGND VGND VPWR VPWR _5101_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_84_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4035_ _6798_/X VGND VGND VPWR VPWR _4617_/A sky130_fd_sc_hd__buf_1
XFILLER_37_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8912_ _8943_/CLK _8912_/D VGND VGND VPWR VPWR _8912_/Q sky130_fd_sc_hd__dfxtp_1
X_8843_ _8907_/CLK _8843_/D VGND VGND VPWR VPWR _8843_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_65_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8774_ _8934_/CLK _8774_/D VGND VGND VPWR VPWR _8774_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5986_ _5986_/A VGND VGND VPWR VPWR _5986_/Y sky130_fd_sc_hd__inv_2
X_4937_ _8544_/Q _4886_/A _4936_/X _4888_/A VGND VGND VPWR VPWR _8544_/D sky130_fd_sc_hd__a22o_1
X_7725_ _8721_/Q _8689_/Q _8657_/Q _8625_/Q _5872_/C _5872_/B VGND VGND VPWR VPWR
+ _7725_/X sky130_fd_sc_hd__mux4_2
XFILLER_52_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4868_ _6807_/X VGND VGND VPWR VPWR _4868_/X sky130_fd_sc_hd__clkbuf_2
XANTENNA_31 _6582_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_20 _5741_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7656_ _7652_/X _7653_/X _7654_/X _7655_/X _7701_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7656_/X sky130_fd_sc_hd__mux4_2
XANTENNA_42 _9068_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_53 _9062_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6607_ _6459_/A _5979_/X _6585_/X VGND VGND VPWR VPWR _6607_/Y sky130_fd_sc_hd__o21ai_1
X_4799_ _8616_/Q _4794_/X _4645_/X _4795_/X VGND VGND VPWR VPWR _8616_/D sky130_fd_sc_hd__a22o_1
X_7587_ _8586_/Q _8138_/Q _8490_/Q _8778_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7587_/X sky130_fd_sc_hd__mux4_1
XFILLER_21_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6538_ _6829_/X _6008_/X _6537_/X VGND VGND VPWR VPWR _6538_/X sky130_fd_sc_hd__o21a_1
X_6469_ _6816_/X VGND VGND VPWR VPWR _6469_/Y sky130_fd_sc_hd__inv_2
XFILLER_97_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8208_ _9075_/CLK _8208_/D VGND VGND VPWR VPWR _8208_/Q sky130_fd_sc_hd__dfxtp_1
X_8139_ _9033_/CLK _8139_/D VGND VGND VPWR VPWR _8139_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_75_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xrepeater107 _6741_/S VGND VGND VPWR VPWR _6705_/S sky130_fd_sc_hd__buf_4
XFILLER_78_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrepeater129 _7610_/S0 VGND VGND VPWR VPWR _7609_/S0 sky130_fd_sc_hd__buf_8
Xrepeater118 _8009_/S1 VGND VGND VPWR VPWR _7985_/S1 sky130_fd_sc_hd__buf_8
XFILLER_66_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5840_ _6570_/A VGND VGND VPWR VPWR _6433_/A sky130_fd_sc_hd__buf_1
X_5771_ _5771_/A _5771_/B _5771_/C VGND VGND VPWR VPWR _5772_/C sky130_fd_sc_hd__or3_2
X_4722_ _8669_/Q _4716_/X _4595_/X _4719_/X VGND VGND VPWR VPWR _8669_/D sky130_fd_sc_hd__a22o_1
X_8490_ _9033_/CLK _8490_/D VGND VGND VPWR VPWR _8490_/Q sky130_fd_sc_hd__dfxtp_1
X_7510_ _8966_/Q _8390_/Q _8166_/Q _8742_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7510_/X sky130_fd_sc_hd__mux4_1
X_7441_ _7437_/X _7438_/X _7439_/X _7440_/X input16/X _7601_/S1 VGND VGND VPWR VPWR
+ _7441_/X sky130_fd_sc_hd__mux4_1
X_4653_ _4653_/A VGND VGND VPWR VPWR _4653_/X sky130_fd_sc_hd__clkbuf_2
X_7372_ _8830_/Q _8350_/Q _8958_/Q _8478_/Q _7374_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7372_/X sky130_fd_sc_hd__mux4_1
X_4584_ _8736_/Q _4555_/A _4388_/X _4556_/A VGND VGND VPWR VPWR _8736_/D sky130_fd_sc_hd__a22o_1
XFILLER_116_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6323_ _9081_/Q _6161_/B _6162_/A VGND VGND VPWR VPWR _6324_/A sky130_fd_sc_hd__o21ai_2
XFILLER_107_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6254_ _6948_/S _6253_/Y _6251_/X VGND VGND VPWR VPWR _6308_/B sky130_fd_sc_hd__o21ai_2
X_9042_ _9044_/CLK _9042_/D VGND VGND VPWR VPWR _9042_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_130_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5205_ _8386_/Q _5194_/X _5204_/X _5196_/X VGND VGND VPWR VPWR _8386_/D sky130_fd_sc_hd__a22o_1
XFILLER_130_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6185_ _6185_/A _6185_/B VGND VGND VPWR VPWR _6185_/X sky130_fd_sc_hd__or2_1
XFILLER_123_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5136_ _5160_/A VGND VGND VPWR VPWR _5136_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_57_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5067_ _5074_/A VGND VGND VPWR VPWR _5067_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_84_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4018_ _6803_/X VGND VGND VPWR VPWR _4605_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_25_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8826_ _8922_/CLK _8826_/D VGND VGND VPWR VPWR _8826_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5969_ _7056_/X _5981_/B VGND VGND VPWR VPWR _5970_/A sky130_fd_sc_hd__nand2_2
XFILLER_13_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8757_ _8757_/CLK _8757_/D VGND VGND VPWR VPWR _8757_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7708_ _8272_/Q _8240_/Q _8208_/Q _9008_/Q _7909_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7708_/X sky130_fd_sc_hd__mux4_1
XFILLER_138_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8688_ _8942_/CLK _8688_/D VGND VGND VPWR VPWR _8688_/Q sky130_fd_sc_hd__dfxtp_1
X_7639_ _8109_/Q _8077_/Q _8045_/Q _9037_/Q _7659_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7639_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7990_ _8990_/Q _8414_/Q _8190_/Q _8766_/Q _7990_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7990_/X sky130_fd_sc_hd__mux4_1
XFILLER_82_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6941_ _6988_/X _6991_/X _6963_/S VGND VGND VPWR VPWR _6941_/X sky130_fd_sc_hd__mux2_1
XFILLER_35_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6872_ _6873_/X _6564_/B _6918_/S VGND VGND VPWR VPWR _6872_/X sky130_fd_sc_hd__mux2_1
XFILLER_35_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8611_ _8710_/CLK _8611_/D VGND VGND VPWR VPWR _8611_/Q sky130_fd_sc_hd__dfxtp_1
X_5823_ _7069_/X VGND VGND VPWR VPWR _5858_/B sky130_fd_sc_hd__inv_2
XFILLER_50_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8542_ _8545_/CLK _8542_/D VGND VGND VPWR VPWR _8542_/Q sky130_fd_sc_hd__dfxtp_1
X_5754_ _8044_/Q _5748_/X _4635_/A _5749_/X VGND VGND VPWR VPWR _8044_/D sky130_fd_sc_hd__a22o_1
X_4705_ _4705_/A VGND VGND VPWR VPWR _4705_/X sky130_fd_sc_hd__clkbuf_2
X_5685_ _8091_/Q _5677_/X _4599_/A _5680_/X VGND VGND VPWR VPWR _8091_/D sky130_fd_sc_hd__a22o_1
X_8473_ _8922_/CLK _8473_/D VGND VGND VPWR VPWR _8473_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_135_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7424_ _8514_/Q _8898_/Q _8834_/Q _8866_/Q _7505_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7424_/X sky130_fd_sc_hd__mux4_2
X_4636_ _8716_/Q _4625_/X _4635_/X _4627_/X VGND VGND VPWR VPWR _8716_/D sky130_fd_sc_hd__a22o_1
XFILLER_135_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7355_ _8732_/Q _8700_/Q _8668_/Q _8636_/Q _6343_/A _6344_/B VGND VGND VPWR VPWR
+ _7355_/X sky130_fd_sc_hd__mux4_2
XFILLER_116_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4567_ _8749_/Q _4562_/X _4358_/X _4563_/X VGND VGND VPWR VPWR _8749_/D sky130_fd_sc_hd__a22o_1
X_6306_ _6570_/A _6305_/Y _6257_/X VGND VGND VPWR VPWR _6398_/A sky130_fd_sc_hd__o21ai_2
XFILLER_2_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4498_ _8796_/Q _4491_/X _4322_/X _4494_/X VGND VGND VPWR VPWR _8796_/D sky130_fd_sc_hd__a22o_1
X_7286_ _7282_/X _7283_/X _7284_/X _7285_/X _7286_/S0 _7381_/S1 VGND VGND VPWR VPWR
+ _7286_/X sky130_fd_sc_hd__mux4_1
X_9025_ _9057_/CLK _9025_/D VGND VGND VPWR VPWR _9025_/Q sky130_fd_sc_hd__dfxtp_1
X_6237_ input5/X VGND VGND VPWR VPWR _6238_/A sky130_fd_sc_hd__inv_2
XFILLER_131_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6168_ _6168_/A VGND VGND VPWR VPWR _6169_/B sky130_fd_sc_hd__inv_2
X_5119_ _8425_/Q _5115_/X _4916_/X _5116_/X VGND VGND VPWR VPWR _8425_/D sky130_fd_sc_hd__a22o_1
X_6099_ _6099_/A VGND VGND VPWR VPWR _6099_/Y sky130_fd_sc_hd__inv_2
XFILLER_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8809_ _8907_/CLK _8809_/D VGND VGND VPWR VPWR _8809_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5470_ _6783_/X VGND VGND VPWR VPWR _5470_/X sky130_fd_sc_hd__clkbuf_2
X_4421_ _8845_/Q _4416_/X _4358_/X _4417_/X VGND VGND VPWR VPWR _8845_/D sky130_fd_sc_hd__a22o_1
XFILLER_8_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7140_ _8966_/Q _8390_/Q _8166_/Q _8742_/Q _7140_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7140_/X sky130_fd_sc_hd__mux4_1
XFILLER_98_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4352_ _4376_/A VGND VGND VPWR VPWR _4352_/X sky130_fd_sc_hd__buf_2
XFILLER_113_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7071_ _8026_/X _8031_/X _7071_/S VGND VGND VPWR VPWR _7071_/X sky130_fd_sc_hd__mux2_2
X_4283_ _8917_/Q _4281_/X _4032_/X _4282_/X VGND VGND VPWR VPWR _8917_/D sky130_fd_sc_hd__a22o_1
XFILLER_101_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6022_ _7039_/X _5996_/X _7042_/X _5979_/X VGND VGND VPWR VPWR _6024_/A sky130_fd_sc_hd__o22a_1
XFILLER_39_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7973_ _8446_/Q _8318_/Q _8382_/Q _8574_/Q _7975_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7973_/X sky130_fd_sc_hd__mux4_2
XFILLER_66_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6924_ _7048_/X _7051_/X _6963_/S VGND VGND VPWR VPWR _6924_/X sky130_fd_sc_hd__mux2_1
XFILLER_54_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6855_ _6896_/X _6895_/X _6932_/S VGND VGND VPWR VPWR _6855_/X sky130_fd_sc_hd__mux2_1
XPHY_1829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5806_ _6875_/X _5914_/B _6875_/X _5914_/B VGND VGND VPWR VPWR _5807_/A sky130_fd_sc_hd__o2bb2a_1
X_6786_ _5891_/Y _5887_/X _6809_/S VGND VGND VPWR VPWR _6786_/X sky130_fd_sc_hd__mux2_2
XFILLER_22_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_3998_ _4034_/A VGND VGND VPWR VPWR _3998_/X sky130_fd_sc_hd__clkbuf_4
X_8525_ _8941_/CLK _8525_/D VGND VGND VPWR VPWR _8525_/Q sky130_fd_sc_hd__dfxtp_1
X_5737_ _8057_/Q _5734_/X _4605_/A _5735_/X VGND VGND VPWR VPWR _8057_/D sky130_fd_sc_hd__a22o_1
XFILLER_129_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8456_ _8456_/CLK _8456_/D VGND VGND VPWR VPWR _8456_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_13_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7407_ _8577_/Q _8129_/Q _8481_/Q _8769_/Q _7990_/S0 _5872_/B VGND VGND VPWR VPWR
+ _7407_/X sky130_fd_sc_hd__mux4_1
X_5668_ _8102_/Q _5666_/X _5467_/X _5667_/X VGND VGND VPWR VPWR _8102_/D sky130_fd_sc_hd__a22o_1
XFILLER_136_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8387_ _9035_/CLK _8387_/D VGND VGND VPWR VPWR _8387_/Q sky130_fd_sc_hd__dfxtp_1
X_4619_ _4619_/A VGND VGND VPWR VPWR _4619_/X sky130_fd_sc_hd__buf_2
X_5599_ _8149_/Q _5597_/X _5431_/X _5598_/X VGND VGND VPWR VPWR _8149_/D sky130_fd_sc_hd__a22o_1
XFILLER_1_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7338_ _8282_/Q _8250_/Q _8218_/Q _9018_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7338_/X sky130_fd_sc_hd__mux4_1
X_7269_ _8115_/Q _8083_/Q _8051_/Q _9043_/Q _7280_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7269_/X sky130_fd_sc_hd__mux4_1
XFILLER_77_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9008_ _9075_/CLK _9008_/D VGND VGND VPWR VPWR _9008_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_89_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4970_ _8524_/Q _4964_/X _4908_/X _4965_/X VGND VGND VPWR VPWR _8524_/D sky130_fd_sc_hd__a22o_1
XFILLER_63_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6640_ _6902_/X _6620_/X _5943_/A _6572_/A _6639_/Y VGND VGND VPWR VPWR _6640_/Y
+ sky130_fd_sc_hd__o221ai_2
XFILLER_20_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6571_ _6571_/A VGND VGND VPWR VPWR _6571_/X sky130_fd_sc_hd__buf_1
XFILLER_118_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5522_ _5522_/A VGND VGND VPWR VPWR _5522_/X sky130_fd_sc_hd__clkbuf_2
X_8310_ _8757_/CLK _8310_/D VGND VGND VPWR VPWR _8310_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_8_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5453_ _8236_/Q _5442_/X _5452_/X _5444_/X VGND VGND VPWR VPWR _8236_/D sky130_fd_sc_hd__a22o_1
X_8241_ _9009_/CLK _8241_/D VGND VGND VPWR VPWR _8241_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_133_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8172_ _9004_/CLK _8172_/D VGND VGND VPWR VPWR _8172_/Q sky130_fd_sc_hd__dfxtp_1
X_5384_ _8270_/Q _5380_/X _5176_/X _5381_/X VGND VGND VPWR VPWR _8270_/D sky130_fd_sc_hd__a22o_1
X_4404_ _8858_/Q _4402_/X _4327_/X _4403_/X VGND VGND VPWR VPWR _8858_/D sky130_fd_sc_hd__a22o_1
X_7123_ _8421_/Q _8293_/Q _8357_/Q _8549_/Q _7135_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7123_/X sky130_fd_sc_hd__mux4_1
XFILLER_113_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4335_ _8887_/Q _4326_/X _4334_/X _4328_/X VGND VGND VPWR VPWR _8887_/D sky130_fd_sc_hd__a22o_1
XFILLER_5_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4266_ _4302_/A VGND VGND VPWR VPWR _4303_/A sky130_fd_sc_hd__inv_2
X_7054_ _6369_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7054_/X sky130_fd_sc_hd__mux2_2
XFILLER_59_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4197_ _8968_/Q _4192_/X _4077_/X _4193_/X VGND VGND VPWR VPWR _8968_/D sky130_fd_sc_hd__a22o_1
XFILLER_86_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6005_ _7030_/X _6002_/X _7033_/X _6004_/Y VGND VGND VPWR VPWR _6025_/C sky130_fd_sc_hd__a22o_1
XFILLER_131_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7956_ _7952_/X _7953_/X _7954_/X _7955_/X _7996_/S0 _5771_/B VGND VGND VPWR VPWR
+ _7956_/X sky130_fd_sc_hd__mux4_2
XFILLER_82_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6907_ _6962_/X _6960_/X _6961_/S VGND VGND VPWR VPWR _6907_/X sky130_fd_sc_hd__mux2_1
X_7887_ _8601_/Q _8153_/Q _8505_/Q _8793_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7887_/X sky130_fd_sc_hd__mux4_1
XFILLER_24_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6838_ _6837_/X _6565_/X _6948_/S VGND VGND VPWR VPWR _6838_/X sky130_fd_sc_hd__mux2_1
XPHY_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8508_ _8956_/CLK _8508_/D VGND VGND VPWR VPWR _8508_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6769_ _6362_/Y _6220_/Y _6777_/S VGND VGND VPWR VPWR _9079_/D sky130_fd_sc_hd__mux2_1
XFILLER_136_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8439_ _8729_/CLK _8439_/D VGND VGND VPWR VPWR _8439_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_124_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4120_ _4127_/A VGND VGND VPWR VPWR _4120_/X sky130_fd_sc_hd__clkbuf_2
X_4051_ _4085_/A VGND VGND VPWR VPWR _4051_/X sky130_fd_sc_hd__buf_2
XFILLER_68_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput5 imData[13] VGND VGND VPWR VPWR input5/X sky130_fd_sc_hd__buf_4
X_7810_ _8981_/Q _8405_/Q _8181_/Q _8757_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7810_/X sky130_fd_sc_hd__mux4_1
XFILLER_36_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8790_ _8790_/CLK _8790_/D VGND VGND VPWR VPWR _8790_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_101_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4953_ _8537_/Q _4950_/X _4878_/X _4951_/X VGND VGND VPWR VPWR _8537_/D sky130_fd_sc_hd__a22o_1
X_7741_ _7737_/X _7738_/X _7739_/X _7740_/X _7801_/S0 _8001_/S1 VGND VGND VPWR VPWR
+ _7741_/X sky130_fd_sc_hd__mux4_2
XFILLER_36_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7672_ _8815_/Q _8335_/Q _8943_/Q _8463_/Q _7697_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7672_/X sky130_fd_sc_hd__mux4_2
X_6623_ _6872_/X _6620_/X _6988_/X _6606_/X _6622_/Y VGND VGND VPWR VPWR _6623_/Y
+ sky130_fd_sc_hd__o221ai_2
XFILLER_32_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4884_ _6800_/X VGND VGND VPWR VPWR _4884_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_137_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6554_ _6472_/X _6475_/Y _6582_/A _6553_/Y VGND VGND VPWR VPWR _6554_/X sky130_fd_sc_hd__o31a_1
X_6485_ _6550_/C _6485_/B VGND VGND VPWR VPWR _6485_/X sky130_fd_sc_hd__or2_1
X_5505_ _8211_/Q _5501_/X _5436_/X _5502_/X VGND VGND VPWR VPWR _8211_/D sky130_fd_sc_hd__a22o_1
XFILLER_9_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8224_ _9024_/CLK _8224_/D VGND VGND VPWR VPWR _8224_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5436_ _6797_/X VGND VGND VPWR VPWR _5436_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_126_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8155_ _9020_/CLK _8155_/D VGND VGND VPWR VPWR _8155_/Q sky130_fd_sc_hd__dfxtp_1
X_5367_ _5374_/A VGND VGND VPWR VPWR _5367_/X sky130_fd_sc_hd__clkbuf_2
X_7106_ _7102_/X _7103_/X _7104_/X _7105_/X _7191_/S0 _7191_/S1 VGND VGND VPWR VPWR
+ _7106_/X sky130_fd_sc_hd__mux4_1
X_5298_ _5298_/A VGND VGND VPWR VPWR _5298_/X sky130_fd_sc_hd__buf_2
XFILLER_101_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4318_ _4593_/A VGND VGND VPWR VPWR _4318_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_59_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8086_ _9048_/CLK _8086_/D VGND VGND VPWR VPWR _8086_/Q sky130_fd_sc_hd__dfxtp_1
X_4249_ _8936_/Q _4244_/X _4077_/X _4245_/X VGND VGND VPWR VPWR _8936_/D sky130_fd_sc_hd__a22o_1
XFILLER_87_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7037_ _7806_/X _7811_/X _7070_/S VGND VGND VPWR VPWR _7037_/X sky130_fd_sc_hd__mux2_1
XFILLER_83_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8988_ _8991_/CLK _8988_/D VGND VGND VPWR VPWR _8988_/Q sky130_fd_sc_hd__dfxtp_1
X_7939_ _8124_/Q _8092_/Q _8060_/Q _9052_/Q _8000_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7939_/X sky130_fd_sc_hd__mux4_2
XFILLER_70_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_1990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6270_ _6265_/A _6265_/B _6265_/X VGND VGND VPWR VPWR _6271_/A sky130_fd_sc_hd__a21bo_1
XFILLER_115_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5221_ _8379_/Q _5212_/X _5144_/X _5216_/X VGND VGND VPWR VPWR _8379_/D sky130_fd_sc_hd__a22o_1
XFILLER_97_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5152_ _6802_/X VGND VGND VPWR VPWR _5152_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_57_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4103_ _4663_/A VGND VGND VPWR VPWR _4103_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_110_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5083_ _5083_/A _5307_/B VGND VGND VPWR VPWR _5122_/A sky130_fd_sc_hd__or2_4
X_4034_ _4034_/A VGND VGND VPWR VPWR _4034_/X sky130_fd_sc_hd__clkbuf_4
X_8911_ _8911_/CLK _8911_/D VGND VGND VPWR VPWR _8911_/Q sky130_fd_sc_hd__dfxtp_1
X_8842_ _8938_/CLK _8842_/D VGND VGND VPWR VPWR _8842_/Q sky130_fd_sc_hd__dfxtp_1
X_8773_ _8933_/CLK _8773_/D VGND VGND VPWR VPWR _8773_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5985_ _7044_/X _5985_/B VGND VGND VPWR VPWR _5986_/A sky130_fd_sc_hd__nand2_2
XFILLER_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7724_ _8529_/Q _8913_/Q _8849_/Q _8881_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7724_/X sky130_fd_sc_hd__mux4_1
XFILLER_80_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4936_ _6778_/X VGND VGND VPWR VPWR _4936_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_21_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_10 _4754_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_21 _5862_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4867_ _8574_/Q _4861_/X _4866_/X _4864_/X VGND VGND VPWR VPWR _8574_/D sky130_fd_sc_hd__a22o_1
X_7655_ _8718_/Q _8686_/Q _8654_/Q _8622_/Q _7655_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7655_/X sky130_fd_sc_hd__mux4_1
XANTENNA_32 _6571_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7586_ _7582_/X _7583_/X _7584_/X _7585_/X _8006_/S0 _7611_/S1 VGND VGND VPWR VPWR
+ _7586_/X sky130_fd_sc_hd__mux4_2
XANTENNA_54 _9062_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_43 _9070_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6606_ _6606_/A VGND VGND VPWR VPWR _6606_/X sky130_fd_sc_hd__buf_2
X_4798_ _8617_/Q _4794_/X _4643_/X _4795_/X VGND VGND VPWR VPWR _8617_/D sky130_fd_sc_hd__a22o_1
XFILLER_119_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6537_ _6829_/X _6008_/A _6830_/X _6010_/Y VGND VGND VPWR VPWR _6537_/X sky130_fd_sc_hd__a22o_1
XFILLER_119_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6468_ _6437_/A _6466_/Y _7066_/X _5982_/A _6467_/X VGND VGND VPWR VPWR _6468_/X
+ sky130_fd_sc_hd__a32o_1
X_6399_ _6304_/Y _6396_/A _6259_/Y VGND VGND VPWR VPWR _6399_/Y sky130_fd_sc_hd__o21ai_1
X_5419_ _6804_/X VGND VGND VPWR VPWR _5419_/X sky130_fd_sc_hd__clkbuf_2
X_8207_ _8975_/CLK _8207_/D VGND VGND VPWR VPWR _8207_/Q sky130_fd_sc_hd__dfxtp_1
X_8138_ _8778_/CLK _8138_/D VGND VGND VPWR VPWR _8138_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_99_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8069_ _9029_/CLK _8069_/D VGND VGND VPWR VPWR _8069_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_9_0_clk clkbuf_4_9_0_clk/A VGND VGND VPWR VPWR clkbuf_opt_0_clk/A sky130_fd_sc_hd__clkbuf_1
Xrepeater108 _6745_/S VGND VGND VPWR VPWR _6741_/S sky130_fd_sc_hd__buf_4
XFILLER_39_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater119 _8009_/S1 VGND VGND VPWR VPWR _8010_/S1 sky130_fd_sc_hd__buf_8
XFILLER_66_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5770_ _8032_/Q _5741_/A _4663_/A _5742_/A VGND VGND VPWR VPWR _8032_/D sky130_fd_sc_hd__a22o_1
X_4721_ _8670_/Q _4716_/X _4593_/X _4719_/X VGND VGND VPWR VPWR _8670_/D sky130_fd_sc_hd__a22o_1
X_4652_ _8710_/Q _4649_/X _4650_/X _4651_/X VGND VGND VPWR VPWR _8710_/D sky130_fd_sc_hd__a22o_1
X_7440_ _8963_/Q _8387_/Q _8163_/Q _8739_/Q _7500_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7440_/X sky130_fd_sc_hd__mux4_1
XFILLER_135_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput30 imData[7] VGND VGND VPWR VPWR _6939_/S sky130_fd_sc_hd__buf_4
XFILLER_116_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4583_ _8737_/Q _4555_/A _4386_/X _4556_/A VGND VGND VPWR VPWR _8737_/D sky130_fd_sc_hd__a22o_1
X_7371_ _7367_/X _7368_/X _7369_/X _7370_/X _7391_/S0 _7381_/S1 VGND VGND VPWR VPWR
+ _7371_/X sky130_fd_sc_hd__mux4_1
XFILLER_116_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6322_ _6178_/X _6320_/Y _6321_/X VGND VGND VPWR VPWR _6333_/A sky130_fd_sc_hd__o21ai_2
X_9041_ _9050_/CLK _9041_/D VGND VGND VPWR VPWR _9041_/Q sky130_fd_sc_hd__dfxtp_1
X_6253_ _6253_/A VGND VGND VPWR VPWR _6253_/Y sky130_fd_sc_hd__inv_2
XFILLER_131_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5204_ _6780_/X VGND VGND VPWR VPWR _5204_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_130_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6184_ _6185_/B VGND VGND VPWR VPWR _6184_/Y sky130_fd_sc_hd__inv_2
XFILLER_97_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5135_ _5196_/A VGND VGND VPWR VPWR _5160_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_123_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5066_ _8460_/Q _5060_/X _4908_/X _5061_/X VGND VGND VPWR VPWR _8460_/D sky130_fd_sc_hd__a22o_1
XFILLER_38_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4017_ _4034_/A VGND VGND VPWR VPWR _4017_/X sky130_fd_sc_hd__buf_2
XFILLER_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8825_ _8953_/CLK _8825_/D VGND VGND VPWR VPWR _8825_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5968_ _5968_/A VGND VGND VPWR VPWR _5988_/B sky130_fd_sc_hd__inv_2
XFILLER_12_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8756_ _9044_/CLK _8756_/D VGND VGND VPWR VPWR _8756_/Q sky130_fd_sc_hd__dfxtp_1
X_4919_ _8552_/Q _4910_/X _4918_/X _4912_/X VGND VGND VPWR VPWR _8552_/D sky130_fd_sc_hd__a22o_1
XFILLER_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7707_ _8592_/Q _8144_/Q _8496_/Q _8784_/Q _7710_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7707_/X sky130_fd_sc_hd__mux4_2
XFILLER_40_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5899_ _5918_/A _5899_/B VGND VGND VPWR VPWR _6559_/B sky130_fd_sc_hd__or2_1
X_8687_ _8911_/CLK _8687_/D VGND VGND VPWR VPWR _8687_/Q sky130_fd_sc_hd__dfxtp_1
X_7638_ _8269_/Q _8237_/Q _8205_/Q _9005_/Q _7659_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7638_/X sky130_fd_sc_hd__mux4_1
X_7569_ _8105_/Q _8073_/Q _8041_/Q _9033_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7569_/X sky130_fd_sc_hd__mux4_2
XFILLER_134_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6940_ _6994_/X _6997_/X _6963_/S VGND VGND VPWR VPWR _6940_/X sky130_fd_sc_hd__mux2_1
XFILLER_54_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6871_ _6870_/X _6872_/X _6948_/S VGND VGND VPWR VPWR _6871_/X sky130_fd_sc_hd__mux2_1
XFILLER_19_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8610_ _8709_/CLK _8610_/D VGND VGND VPWR VPWR _8610_/Q sky130_fd_sc_hd__dfxtp_1
X_5822_ _5822_/A VGND VGND VPWR VPWR _5822_/Y sky130_fd_sc_hd__inv_2
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8541_ _8863_/CLK _8541_/D VGND VGND VPWR VPWR _8541_/Q sky130_fd_sc_hd__dfxtp_1
X_5753_ _8045_/Q _5748_/X _4633_/A _5749_/X VGND VGND VPWR VPWR _8045_/D sky130_fd_sc_hd__a22o_1
X_4704_ _8679_/Q _4698_/X _4647_/X _4699_/X VGND VGND VPWR VPWR _8679_/D sky130_fd_sc_hd__a22o_1
XFILLER_136_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5684_ _8092_/Q _5677_/X _4597_/A _5680_/X VGND VGND VPWR VPWR _8092_/D sky130_fd_sc_hd__a22o_1
X_8472_ _8954_/CLK _8472_/D VGND VGND VPWR VPWR _8472_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_30_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7423_ _8418_/Q _8290_/Q _8354_/Q _8546_/Q _7505_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7423_/X sky130_fd_sc_hd__mux4_1
X_4635_ _4635_/A VGND VGND VPWR VPWR _4635_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7354_ _8540_/Q _8924_/Q _8860_/Q _8892_/Q _7390_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7354_/X sky130_fd_sc_hd__mux4_1
X_4566_ _8750_/Q _4562_/X _4356_/X _4563_/X VGND VGND VPWR VPWR _8750_/D sky130_fd_sc_hd__a22o_1
XFILLER_104_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6305_ _6305_/A VGND VGND VPWR VPWR _6305_/Y sky130_fd_sc_hd__inv_2
XFILLER_103_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4497_ _8797_/Q _4491_/X _4320_/X _4494_/X VGND VGND VPWR VPWR _8797_/D sky130_fd_sc_hd__a22o_1
X_7285_ _8725_/Q _8693_/Q _8661_/Q _8629_/Q _7369_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7285_/X sky130_fd_sc_hd__mux4_1
X_9024_ _9024_/CLK _9024_/D VGND VGND VPWR VPWR _9024_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_134_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6236_ _6238_/B VGND VGND VPWR VPWR _6236_/Y sky130_fd_sc_hd__inv_2
XFILLER_58_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6167_ _9084_/Q _6167_/B VGND VGND VPWR VPWR _6168_/A sky130_fd_sc_hd__nand2_1
X_5118_ _8426_/Q _5115_/X _4914_/X _5116_/X VGND VGND VPWR VPWR _8426_/D sky130_fd_sc_hd__a22o_1
XFILLER_94_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6098_ _6098_/A VGND VGND VPWR VPWR _6098_/Y sky130_fd_sc_hd__inv_2
XFILLER_72_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5049_ _8473_/Q _5046_/X _4878_/X _5047_/X VGND VGND VPWR VPWR _8473_/D sky130_fd_sc_hd__a22o_1
XFILLER_72_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8808_ _8939_/CLK _8808_/D VGND VGND VPWR VPWR _8808_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8739_ _8966_/CLK _8739_/D VGND VGND VPWR VPWR _8739_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4420_ _8846_/Q _4416_/X _4356_/X _4417_/X VGND VGND VPWR VPWR _8846_/D sky130_fd_sc_hd__a22o_1
XFILLER_125_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4351_ _4626_/A VGND VGND VPWR VPWR _4351_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_125_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7070_ _8016_/X _8021_/X _7070_/S VGND VGND VPWR VPWR _7070_/X sky130_fd_sc_hd__mux2_1
X_4282_ _4282_/A VGND VGND VPWR VPWR _4282_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_86_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6021_ _6025_/C _6019_/X _6020_/X VGND VGND VPWR VPWR _6021_/X sky130_fd_sc_hd__o21a_1
XFILLER_67_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7972_ _8830_/Q _8350_/Q _8958_/Q _8478_/Q _7975_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7972_/X sky130_fd_sc_hd__mux4_1
XFILLER_54_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6923_ _7054_/X _7057_/X _6963_/S VGND VGND VPWR VPWR _6923_/X sky130_fd_sc_hd__mux2_1
XFILLER_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6854_ _5902_/X _6997_/X _6943_/S VGND VGND VPWR VPWR _6854_/X sky130_fd_sc_hd__mux2_2
XFILLER_62_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5805_ _5832_/C _5805_/B VGND VGND VPWR VPWR _5805_/X sky130_fd_sc_hd__or2_1
X_3997_ _4085_/A VGND VGND VPWR VPWR _4034_/A sky130_fd_sc_hd__buf_2
X_6785_ _5901_/Y _5895_/Y _6809_/S VGND VGND VPWR VPWR _6785_/X sky130_fd_sc_hd__mux2_2
XFILLER_13_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8524_ _8940_/CLK _8524_/D VGND VGND VPWR VPWR _8524_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5736_ _8058_/Q _5734_/X _4602_/A _5735_/X VGND VGND VPWR VPWR _8058_/D sky130_fd_sc_hd__a22o_1
X_8455_ _8811_/CLK _8455_/D VGND VGND VPWR VPWR _8455_/Q sky130_fd_sc_hd__dfxtp_1
X_5667_ _5667_/A VGND VGND VPWR VPWR _5667_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_136_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7406_ _7402_/X _7403_/X _7404_/X _7405_/X _8011_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _7406_/X sky130_fd_sc_hd__mux4_2
X_4618_ _8724_/Q _4613_/X _4617_/X _4615_/X VGND VGND VPWR VPWR _8724_/D sky130_fd_sc_hd__a22o_1
X_8386_ _8998_/CLK _8386_/D VGND VGND VPWR VPWR _8386_/Q sky130_fd_sc_hd__dfxtp_1
X_5598_ _5598_/A VGND VGND VPWR VPWR _5598_/X sky130_fd_sc_hd__buf_2
XFILLER_132_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7337_ _8602_/Q _8154_/Q _8506_/Q _8794_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7337_/X sky130_fd_sc_hd__mux4_2
X_4549_ _4556_/A VGND VGND VPWR VPWR _4549_/X sky130_fd_sc_hd__clkbuf_2
X_7268_ _8275_/Q _8243_/Q _8211_/Q _9011_/Q _7280_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7268_/X sky130_fd_sc_hd__mux4_1
XFILLER_1_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9007_ _9067_/CLK _9007_/D VGND VGND VPWR VPWR _9007_/Q sky130_fd_sc_hd__dfxtp_1
X_6219_ _9079_/Q _6157_/B _6158_/A VGND VGND VPWR VPWR _6220_/A sky130_fd_sc_hd__o21ai_2
X_7199_ _8108_/Q _8076_/Q _8044_/Q _9036_/Q _7229_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7199_/X sky130_fd_sc_hd__mux4_1
XFILLER_85_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6570_ _6570_/A _6570_/B VGND VGND VPWR VPWR _6571_/A sky130_fd_sc_hd__or2_1
XFILLER_20_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5521_ _8199_/Q _5515_/X _5464_/X _5516_/X VGND VGND VPWR VPWR _8199_/D sky130_fd_sc_hd__a22o_1
XFILLER_13_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8240_ _9075_/CLK _8240_/D VGND VGND VPWR VPWR _8240_/Q sky130_fd_sc_hd__dfxtp_1
X_5452_ _6790_/X VGND VGND VPWR VPWR _5452_/X sky130_fd_sc_hd__clkbuf_2
X_8171_ _9031_/CLK _8171_/D VGND VGND VPWR VPWR _8171_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_114_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4403_ _4410_/A VGND VGND VPWR VPWR _4403_/X sky130_fd_sc_hd__clkbuf_2
X_5383_ _8271_/Q _5380_/X _5174_/X _5381_/X VGND VGND VPWR VPWR _8271_/D sky130_fd_sc_hd__a22o_1
X_7122_ _8805_/Q _8325_/Q _8933_/Q _8453_/Q _7135_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7122_/X sky130_fd_sc_hd__mux4_2
X_4334_ _4609_/A VGND VGND VPWR VPWR _4334_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_5_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7053_ _7916_/X _7921_/X _7053_/S VGND VGND VPWR VPWR _7053_/X sky130_fd_sc_hd__mux2_2
X_4265_ _4281_/A VGND VGND VPWR VPWR _4265_/X sky130_fd_sc_hd__clkbuf_2
X_6004_ _6004_/A VGND VGND VPWR VPWR _6004_/Y sky130_fd_sc_hd__inv_2
X_4196_ _8969_/Q _4192_/X _4074_/X _4193_/X VGND VGND VPWR VPWR _8969_/D sky130_fd_sc_hd__a22o_1
XFILLER_55_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7955_ _8733_/Q _8701_/Q _8669_/Q _8637_/Q _7975_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7955_/X sky130_fd_sc_hd__mux4_2
X_6906_ _6959_/X _6956_/X _6961_/S VGND VGND VPWR VPWR _6906_/X sky130_fd_sc_hd__mux2_1
X_7886_ _7882_/X _7883_/X _7884_/X _7885_/X _5872_/A _5873_/B VGND VGND VPWR VPWR
+ _7886_/X sky130_fd_sc_hd__mux4_1
XPHY_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6837_ _6874_/X _6873_/X _6918_/S VGND VGND VPWR VPWR _6837_/X sky130_fd_sc_hd__mux2_1
XFILLER_50_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8507_ _8991_/CLK _8507_/D VGND VGND VPWR VPWR _8507_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_7_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6768_ _6366_/Y _6216_/Y _6777_/S VGND VGND VPWR VPWR _9078_/D sky130_fd_sc_hd__mux2_1
X_5719_ _8067_/Q _5714_/X _4657_/A _5715_/X VGND VGND VPWR VPWR _8067_/D sky130_fd_sc_hd__a22o_1
X_6699_ _6698_/X _9064_/Q _6705_/S VGND VGND VPWR VPWR _6699_/X sky130_fd_sc_hd__mux2_4
X_8438_ _8822_/CLK _8438_/D VGND VGND VPWR VPWR _8438_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_123_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8369_ _9013_/CLK _8369_/D VGND VGND VPWR VPWR _8369_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_123_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4050_ _9040_/Q _4034_/X _4049_/X _4037_/X VGND VGND VPWR VPWR _9040_/D sky130_fd_sc_hd__a22o_1
XFILLER_83_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput6 imData[14] VGND VGND VPWR VPWR input6/X sky130_fd_sc_hd__buf_2
XFILLER_37_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4952_ _8538_/Q _4950_/X _4875_/X _4951_/X VGND VGND VPWR VPWR _8538_/D sky130_fd_sc_hd__a22o_1
X_7740_ _8978_/Q _8402_/Q _8178_/Q _8754_/Q _7798_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7740_/X sky130_fd_sc_hd__mux4_1
X_7671_ _7667_/X _7668_/X _7669_/X _7670_/X _7711_/S0 input11/X VGND VGND VPWR VPWR
+ _7671_/X sky130_fd_sc_hd__mux4_1
X_4883_ _8567_/Q _4874_/X _4882_/X _4876_/X VGND VGND VPWR VPWR _8567_/D sky130_fd_sc_hd__a22o_1
X_6622_ _6458_/A _5999_/X _6621_/X VGND VGND VPWR VPWR _6622_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_20_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6553_ _6553_/A VGND VGND VPWR VPWR _6553_/Y sky130_fd_sc_hd__inv_2
XFILLER_20_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6484_ _6821_/X _6482_/X _6483_/X VGND VGND VPWR VPWR _6485_/B sky130_fd_sc_hd__o21ai_1
X_5504_ _8212_/Q _5501_/X _5434_/X _5502_/X VGND VGND VPWR VPWR _8212_/D sky130_fd_sc_hd__a22o_1
X_8223_ _9052_/CLK _8223_/D VGND VGND VPWR VPWR _8223_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5435_ _8244_/Q _5430_/X _5434_/X _5432_/X VGND VGND VPWR VPWR _8244_/D sky130_fd_sc_hd__a22o_1
XFILLER_126_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8154_ _8986_/CLK _8154_/D VGND VGND VPWR VPWR _8154_/Q sky130_fd_sc_hd__dfxtp_1
X_5366_ _5373_/A VGND VGND VPWR VPWR _5366_/X sky130_fd_sc_hd__clkbuf_2
X_7105_ _8707_/Q _8675_/Q _8643_/Q _8611_/Q _7179_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7105_/X sky130_fd_sc_hd__mux4_2
XFILLER_113_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5297_ _8327_/Q _5291_/X _5192_/X _5292_/X VGND VGND VPWR VPWR _8327_/D sky130_fd_sc_hd__a22o_1
X_4317_ _8895_/Q _4313_/X _4111_/X _4316_/X VGND VGND VPWR VPWR _8895_/D sky130_fd_sc_hd__a22o_1
X_8085_ _9050_/CLK _8085_/D VGND VGND VPWR VPWR _8085_/Q sky130_fd_sc_hd__dfxtp_1
X_4248_ _8937_/Q _4244_/X _4074_/X _4245_/X VGND VGND VPWR VPWR _8937_/D sky130_fd_sc_hd__a22o_1
X_7036_ _6432_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7036_/X sky130_fd_sc_hd__mux2_2
XFILLER_68_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4179_ _4179_/A VGND VGND VPWR VPWR _4179_/X sky130_fd_sc_hd__buf_2
X_8987_ _9052_/CLK _8987_/D VGND VGND VPWR VPWR _8987_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_70_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7938_ _8284_/Q _8252_/Q _8220_/Q _9020_/Q _8000_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7938_/X sky130_fd_sc_hd__mux4_1
XFILLER_70_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7869_ _8120_/Q _8088_/Q _8056_/Q _9048_/Q _7909_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7869_/X sky130_fd_sc_hd__mux4_2
XPHY_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5220_ _8380_/Q _5212_/X _5142_/X _5216_/X VGND VGND VPWR VPWR _8380_/D sky130_fd_sc_hd__a22o_1
XFILLER_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5151_ _8409_/Q _5146_/X _5150_/X _5148_/X VGND VGND VPWR VPWR _8409_/D sky130_fd_sc_hd__a22o_1
X_5082_ _8448_/Q _5053_/A _4936_/X _5054_/A VGND VGND VPWR VPWR _8448_/D sky130_fd_sc_hd__a22o_1
X_4102_ _6778_/X VGND VGND VPWR VPWR _4663_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_110_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8910_ _8942_/CLK _8910_/D VGND VGND VPWR VPWR _8910_/Q sky130_fd_sc_hd__dfxtp_1
X_4033_ _9045_/Q _4017_/X _4032_/X _4020_/X VGND VGND VPWR VPWR _9045_/D sky130_fd_sc_hd__a22o_1
XFILLER_49_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8841_ _8841_/CLK _8841_/D VGND VGND VPWR VPWR _8841_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8772_ _8966_/CLK _8772_/D VGND VGND VPWR VPWR _8772_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_92_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5984_ _7060_/X _5965_/A _7057_/X _5970_/Y VGND VGND VPWR VPWR _5992_/A sky130_fd_sc_hd__o22a_1
X_7723_ _8433_/Q _8305_/Q _8369_/Q _8561_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7723_/X sky130_fd_sc_hd__mux4_1
X_4935_ _8545_/Q _4886_/A _4934_/X _4888_/A VGND VGND VPWR VPWR _8545_/D sky130_fd_sc_hd__a22o_1
XFILLER_21_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_11 _5074_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_22 _5943_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4866_ _6808_/X VGND VGND VPWR VPWR _4866_/X sky130_fd_sc_hd__clkbuf_2
X_7654_ _8526_/Q _8910_/Q _8846_/Q _8878_/Q _7655_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7654_/X sky130_fd_sc_hd__mux4_1
XFILLER_33_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4797_ _8618_/Q _4794_/X _4641_/X _4795_/X VGND VGND VPWR VPWR _8618_/D sky130_fd_sc_hd__a22o_1
X_7585_ _8714_/Q _8682_/Q _8650_/Q _8618_/Q input8/X _7985_/S1 VGND VGND VPWR VPWR
+ _7585_/X sky130_fd_sc_hd__mux4_1
XANTENNA_44 _9071_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_55 _9062_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6605_ _6604_/X _7025_/X VGND VGND VPWR VPWR _6605_/Y sky130_fd_sc_hd__nand2b_1
XANTENNA_33 _6604_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6536_ _6536_/A VGND VGND VPWR VPWR _6536_/Y sky130_fd_sc_hd__inv_2
XFILLER_21_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6467_ _6467_/A _6467_/B VGND VGND VPWR VPWR _6467_/X sky130_fd_sc_hd__or2_1
X_8206_ _9067_/CLK _8206_/D VGND VGND VPWR VPWR _8206_/Q sky130_fd_sc_hd__dfxtp_1
X_5418_ _5430_/A VGND VGND VPWR VPWR _5418_/X sky130_fd_sc_hd__clkbuf_2
X_6398_ _6398_/A VGND VGND VPWR VPWR _6398_/Y sky130_fd_sc_hd__inv_2
X_8137_ _8938_/CLK _8137_/D VGND VGND VPWR VPWR _8137_/Q sky130_fd_sc_hd__dfxtp_1
X_5349_ _8293_/Q _5346_/X _5198_/X _5347_/X VGND VGND VPWR VPWR _8293_/D sky130_fd_sc_hd__a22o_1
XFILLER_99_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8068_ _9027_/CLK _8068_/D VGND VGND VPWR VPWR _8068_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_87_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7019_ _7686_/X _7691_/X _7022_/S VGND VGND VPWR VPWR _7019_/X sky130_fd_sc_hd__mux2_1
XFILLER_55_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_50_clk clkbuf_4_13_0_clk/X VGND VGND VPWR VPWR _8586_/CLK sky130_fd_sc_hd__clkbuf_16
XPHY_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater109 _8009_/S1 VGND VGND VPWR VPWR _5872_/B sky130_fd_sc_hd__buf_8
XFILLER_78_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4720_ _8671_/Q _4716_/X _4668_/X _4719_/X VGND VGND VPWR VPWR _8671_/D sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_41_clk clkbuf_4_6_0_clk/X VGND VGND VPWR VPWR _9056_/CLK sky130_fd_sc_hd__clkbuf_16
X_4651_ _4651_/A VGND VGND VPWR VPWR _4651_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_30_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput20 imData[27] VGND VGND VPWR VPWR _5955_/A sky130_fd_sc_hd__buf_2
Xinput31 imData[8] VGND VGND VPWR VPWR _6932_/S sky130_fd_sc_hd__buf_8
X_4582_ _8738_/Q _4576_/X _4384_/X _4577_/X VGND VGND VPWR VPWR _8738_/D sky130_fd_sc_hd__a22o_1
X_7370_ _8989_/Q _8413_/Q _8189_/Q _8765_/Q _7389_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7370_/X sky130_fd_sc_hd__mux4_1
XFILLER_115_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6321_ _6329_/A _6321_/B VGND VGND VPWR VPWR _6321_/X sky130_fd_sc_hd__or2_1
X_6252_ input3/X _6249_/B _6249_/Y VGND VGND VPWR VPWR _6308_/A sky130_fd_sc_hd__a21o_1
X_9040_ _9075_/CLK _9040_/D VGND VGND VPWR VPWR _9040_/Q sky130_fd_sc_hd__dfxtp_1
X_5203_ _8387_/Q _5194_/X _5202_/X _5196_/X VGND VGND VPWR VPWR _8387_/D sky130_fd_sc_hd__a22o_1
X_6183_ _9085_/Q _6169_/B _6170_/A VGND VGND VPWR VPWR _6185_/B sky130_fd_sc_hd__o21ai_1
X_5134_ _5194_/A VGND VGND VPWR VPWR _5196_/A sky130_fd_sc_hd__inv_2
XFILLER_69_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5065_ _8461_/Q _5060_/X _4906_/X _5061_/X VGND VGND VPWR VPWR _8461_/D sky130_fd_sc_hd__a22o_1
XFILLER_29_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4016_ _9050_/Q _3998_/X _4015_/X _4003_/X VGND VGND VPWR VPWR _9050_/D sky130_fd_sc_hd__a22o_1
XFILLER_65_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8824_ _8950_/CLK _8824_/D VGND VGND VPWR VPWR _8824_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_25_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5967_ _7053_/X _5994_/B VGND VGND VPWR VPWR _5968_/A sky130_fd_sc_hd__nand2_2
XFILLER_53_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8755_ _8787_/CLK _8755_/D VGND VGND VPWR VPWR _8755_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_25_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_32_clk clkbuf_4_7_0_clk/X VGND VGND VPWR VPWR _8713_/CLK sky130_fd_sc_hd__clkbuf_16
X_4918_ _6786_/X VGND VGND VPWR VPWR _4918_/X sky130_fd_sc_hd__clkbuf_2
X_8686_ _8877_/CLK _8686_/D VGND VGND VPWR VPWR _8686_/Q sky130_fd_sc_hd__dfxtp_1
X_7706_ _7702_/X _7703_/X _7704_/X _7705_/X _7711_/S0 input11/X VGND VGND VPWR VPWR
+ _7706_/X sky130_fd_sc_hd__mux4_2
XFILLER_138_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7637_ _8589_/Q _8141_/Q _8493_/Q _8781_/Q _7659_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7637_/X sky130_fd_sc_hd__mux4_2
X_5898_ _6964_/S VGND VGND VPWR VPWR _5918_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_21_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4849_ _4849_/A VGND VGND VPWR VPWR _4849_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_21_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7568_ _8265_/Q _8233_/Q _8201_/Q _9001_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7568_/X sky130_fd_sc_hd__mux4_1
XFILLER_106_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7499_ _8102_/Q _8070_/Q _8038_/Q _9030_/Q _7500_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7499_/X sky130_fd_sc_hd__mux4_1
X_6519_ _6839_/X _6673_/B _6839_/X _6673_/B VGND VGND VPWR VPWR _6523_/A sky130_fd_sc_hd__a2bb2o_1
XFILLER_134_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_99_clk clkbuf_opt_0_clk/A VGND VGND VPWR VPWR _9075_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_130_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_23_clk clkbuf_4_4_0_clk/X VGND VGND VPWR VPWR _8956_/CLK sky130_fd_sc_hd__clkbuf_16
XPHY_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6870_ _6869_/X _6874_/X _6918_/S VGND VGND VPWR VPWR _6870_/X sky130_fd_sc_hd__mux2_1
X_5821_ _7071_/X VGND VGND VPWR VPWR _5821_/Y sky130_fd_sc_hd__inv_2
XFILLER_50_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8540_ _8959_/CLK _8540_/D VGND VGND VPWR VPWR _8540_/Q sky130_fd_sc_hd__dfxtp_1
X_5752_ _8046_/Q _5748_/X _4631_/A _5749_/X VGND VGND VPWR VPWR _8046_/D sky130_fd_sc_hd__a22o_1
X_4703_ _8680_/Q _4698_/X _4645_/X _4699_/X VGND VGND VPWR VPWR _8680_/D sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_14_clk clkbuf_4_6_0_clk/X VGND VGND VPWR VPWR _9054_/CLK sky130_fd_sc_hd__clkbuf_16
X_5683_ _8093_/Q _5677_/X _4595_/A _5680_/X VGND VGND VPWR VPWR _8093_/D sky130_fd_sc_hd__a22o_1
X_8471_ _8922_/CLK _8471_/D VGND VGND VPWR VPWR _8471_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_136_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7422_ _8802_/Q _8322_/Q _8930_/Q _8450_/Q _7505_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7422_/X sky130_fd_sc_hd__mux4_1
X_4634_ _8717_/Q _4625_/X _4633_/X _4627_/X VGND VGND VPWR VPWR _8717_/D sky130_fd_sc_hd__a22o_1
XFILLER_8_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7353_ _8444_/Q _8316_/Q _8380_/Q _8572_/Q _6343_/A _6344_/B VGND VGND VPWR VPWR
+ _7353_/X sky130_fd_sc_hd__mux4_1
X_4565_ _8751_/Q _4562_/X _4354_/X _4563_/X VGND VGND VPWR VPWR _8751_/D sky130_fd_sc_hd__a22o_1
XFILLER_116_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6304_ _6304_/A VGND VGND VPWR VPWR _6304_/Y sky130_fd_sc_hd__inv_2
X_4496_ _8798_/Q _4491_/X _4318_/X _4494_/X VGND VGND VPWR VPWR _8798_/D sky130_fd_sc_hd__a22o_1
XFILLER_89_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9023_ _9052_/CLK _9023_/D VGND VGND VPWR VPWR _9023_/Q sky130_fd_sc_hd__dfxtp_1
X_7284_ _8533_/Q _8917_/Q _8853_/Q _8885_/Q _7369_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7284_/X sky130_fd_sc_hd__mux4_1
X_6235_ _9069_/Q _6234_/Y _6223_/X VGND VGND VPWR VPWR _6238_/B sky130_fd_sc_hd__o21ai_2
XFILLER_134_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6166_ _6166_/A VGND VGND VPWR VPWR _6167_/B sky130_fd_sc_hd__inv_2
X_5117_ _8427_/Q _5115_/X _4911_/X _5116_/X VGND VGND VPWR VPWR _8427_/D sky130_fd_sc_hd__a22o_1
XFILLER_111_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6097_ _6097_/A VGND VGND VPWR VPWR _6097_/Y sky130_fd_sc_hd__inv_2
X_5048_ _8474_/Q _5046_/X _4875_/X _5047_/X VGND VGND VPWR VPWR _8474_/D sky130_fd_sc_hd__a22o_1
XFILLER_57_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8807_ _8811_/CLK _8807_/D VGND VGND VPWR VPWR _8807_/Q sky130_fd_sc_hd__dfxtp_1
X_6999_ _7556_/X _7561_/X _7071_/S VGND VGND VPWR VPWR _6999_/X sky130_fd_sc_hd__mux2_2
X_8738_ _8933_/CLK _8738_/D VGND VGND VPWR VPWR _8738_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_8_0_clk clkbuf_4_9_0_clk/A VGND VGND VPWR VPWR clkbuf_4_8_0_clk/X sky130_fd_sc_hd__clkbuf_1
XFILLER_13_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8669_ _8669_/CLK _8669_/D VGND VGND VPWR VPWR _8669_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_111_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4350_ _4374_/A VGND VGND VPWR VPWR _4350_/X sky130_fd_sc_hd__buf_2
XFILLER_113_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4281_ _4281_/A VGND VGND VPWR VPWR _4281_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_67_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6020_ _7036_/X _5999_/X _7033_/X _6004_/Y VGND VGND VPWR VPWR _6020_/X sky130_fd_sc_hd__o22a_1
Xclkbuf_leaf_3_clk clkbuf_4_1_0_clk/X VGND VGND VPWR VPWR _8947_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_100_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7971_ _7967_/X _7968_/X _7969_/X _7970_/X _8011_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _7971_/X sky130_fd_sc_hd__mux4_1
XFILLER_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6922_ _6924_/X _6923_/X _6961_/S VGND VGND VPWR VPWR _6922_/X sky130_fd_sc_hd__mux2_1
XFILLER_81_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6853_ _6852_/X _5889_/X _6948_/S VGND VGND VPWR VPWR _6853_/X sky130_fd_sc_hd__mux2_1
X_5804_ _6875_/X _5914_/B _5803_/X VGND VGND VPWR VPWR _5805_/B sky130_fd_sc_hd__o21ai_1
XPHY_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3996_ _4537_/A _5723_/A VGND VGND VPWR VPWR _4085_/A sky130_fd_sc_hd__or2_4
X_6784_ _5909_/Y _5904_/Y _6809_/S VGND VGND VPWR VPWR _6784_/X sky130_fd_sc_hd__mux2_4
X_8523_ _8907_/CLK _8523_/D VGND VGND VPWR VPWR _8523_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5735_ _5742_/A VGND VGND VPWR VPWR _5735_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_129_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8454_ _8868_/CLK _8454_/D VGND VGND VPWR VPWR _8454_/Q sky130_fd_sc_hd__dfxtp_1
X_5666_ _5666_/A VGND VGND VPWR VPWR _5666_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_135_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7405_ _8705_/Q _8673_/Q _8641_/Q _8609_/Q _7550_/S0 _7604_/S1 VGND VGND VPWR VPWR
+ _7405_/X sky130_fd_sc_hd__mux4_1
X_4617_ _4617_/A VGND VGND VPWR VPWR _4617_/X sky130_fd_sc_hd__clkbuf_2
X_8385_ _9055_/CLK _8385_/D VGND VGND VPWR VPWR _8385_/Q sky130_fd_sc_hd__dfxtp_1
X_5597_ _5597_/A VGND VGND VPWR VPWR _5597_/X sky130_fd_sc_hd__buf_2
XFILLER_1_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7336_ _7332_/X _7333_/X _7334_/X _7335_/X _7341_/S0 _7336_/S1 VGND VGND VPWR VPWR
+ _7336_/X sky130_fd_sc_hd__mux4_2
X_4548_ _4555_/A VGND VGND VPWR VPWR _4548_/X sky130_fd_sc_hd__clkbuf_2
X_4479_ _4479_/A VGND VGND VPWR VPWR _4479_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_89_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7267_ _8595_/Q _8147_/Q _8499_/Q _8787_/Q _7280_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7267_/X sky130_fd_sc_hd__mux4_1
XFILLER_131_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9006_ _9038_/CLK _9006_/D VGND VGND VPWR VPWR _9006_/Q sky130_fd_sc_hd__dfxtp_1
X_6218_ _6177_/A _6216_/Y _6217_/X VGND VGND VPWR VPWR _6222_/B sky130_fd_sc_hd__o21ai_2
XFILLER_131_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7198_ _8268_/Q _8236_/Q _8204_/Q _9004_/Q _7229_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7198_/X sky130_fd_sc_hd__mux4_2
XFILLER_57_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6149_ _9073_/Q _6149_/B VGND VGND VPWR VPWR _6150_/A sky130_fd_sc_hd__nand2_1
XFILLER_100_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater270 _6098_/A VGND VGND VPWR VPWR _5872_/A sky130_fd_sc_hd__buf_8
XFILLER_45_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5520_ _8200_/Q _5515_/X _5462_/X _5516_/X VGND VGND VPWR VPWR _8200_/D sky130_fd_sc_hd__a22o_1
XFILLER_74_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5451_ _8237_/Q _5442_/X _5450_/X _5444_/X VGND VGND VPWR VPWR _8237_/D sky130_fd_sc_hd__a22o_1
X_8170_ _9034_/CLK _8170_/D VGND VGND VPWR VPWR _8170_/Q sky130_fd_sc_hd__dfxtp_1
X_5382_ _8272_/Q _5380_/X _5171_/X _5381_/X VGND VGND VPWR VPWR _8272_/D sky130_fd_sc_hd__a22o_1
X_4402_ _4409_/A VGND VGND VPWR VPWR _4402_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_113_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7121_ _7117_/X _7118_/X _7119_/X _7120_/X input35/X _7191_/S1 VGND VGND VPWR VPWR
+ _7121_/X sky130_fd_sc_hd__mux4_2
X_4333_ _8888_/Q _4326_/X _4332_/X _4328_/X VGND VGND VPWR VPWR _8888_/D sky130_fd_sc_hd__a22o_1
XFILLER_113_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4264_ _4302_/A VGND VGND VPWR VPWR _4281_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_5_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7052_ _7906_/X _7911_/X _7070_/S VGND VGND VPWR VPWR _7052_/X sky130_fd_sc_hd__mux2_1
XFILLER_113_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6003_ _7032_/X _6032_/B VGND VGND VPWR VPWR _6004_/A sky130_fd_sc_hd__nand2_2
X_4195_ _8970_/Q _4192_/X _4070_/X _4193_/X VGND VGND VPWR VPWR _8970_/D sky130_fd_sc_hd__a22o_1
XFILLER_39_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_131_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7954_ _8541_/Q _8925_/Q _8861_/Q _8893_/Q _7975_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7954_/X sky130_fd_sc_hd__mux4_1
XFILLER_55_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6905_ _6907_/X _6906_/X _6964_/S VGND VGND VPWR VPWR _6905_/X sky130_fd_sc_hd__mux2_1
XFILLER_82_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7885_ _8729_/Q _8697_/Q _8665_/Q _8633_/Q _7885_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7885_/X sky130_fd_sc_hd__mux4_2
XFILLER_23_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6836_ _6675_/X _7015_/X _6943_/S VGND VGND VPWR VPWR _6836_/X sky130_fd_sc_hd__mux2_2
XFILLER_23_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6767_ _6365_/Y _6212_/Y _6777_/S VGND VGND VPWR VPWR _9077_/D sky130_fd_sc_hd__mux2_1
XFILLER_23_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5718_ _8068_/Q _5714_/X _4655_/A _5715_/X VGND VGND VPWR VPWR _8068_/D sky130_fd_sc_hd__a22o_1
X_3979_ _3985_/A _5955_/D _5955_/B _3979_/D VGND VGND VPWR VPWR _6435_/B sky130_fd_sc_hd__or4_4
X_8506_ _8952_/CLK _8506_/D VGND VGND VPWR VPWR _8506_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_109_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6698_ _7156_/X _7161_/X _6744_/S VGND VGND VPWR VPWR _6698_/X sky130_fd_sc_hd__mux2_1
XFILLER_40_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8437_ _8821_/CLK _8437_/D VGND VGND VPWR VPWR _8437_/Q sky130_fd_sc_hd__dfxtp_1
X_5649_ _8115_/Q _5645_/X _5436_/X _5646_/X VGND VGND VPWR VPWR _8115_/D sky130_fd_sc_hd__a22o_1
XFILLER_40_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8368_ _8816_/CLK _8368_/D VGND VGND VPWR VPWR _8368_/Q sky130_fd_sc_hd__dfxtp_1
X_7319_ _8120_/Q _8088_/Q _8056_/Q _9048_/Q _7339_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7319_/X sky130_fd_sc_hd__mux4_2
XFILLER_120_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8299_ _8841_/CLK _8299_/D VGND VGND VPWR VPWR _8299_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_131_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput7 imData[15] VGND VGND VPWR VPWR input7/X sky130_fd_sc_hd__clkbuf_4
XFILLER_49_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4951_ _4958_/A VGND VGND VPWR VPWR _4951_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_60_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7670_ _8974_/Q _8398_/Q _8174_/Q _8750_/Q _7689_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7670_/X sky130_fd_sc_hd__mux4_1
X_4882_ _6801_/X VGND VGND VPWR VPWR _4882_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_20_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6621_ _6621_/A VGND VGND VPWR VPWR _6621_/X sky130_fd_sc_hd__buf_1
XFILLER_20_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6552_ _6818_/X _5970_/Y _6471_/X _6817_/X _6471_/B VGND VGND VPWR VPWR _6553_/A
+ sky130_fd_sc_hd__a32o_1
X_6483_ _6821_/X _6482_/X _6822_/X _5986_/Y VGND VGND VPWR VPWR _6483_/X sky130_fd_sc_hd__a22o_1
X_5503_ _8213_/Q _5501_/X _5431_/X _5502_/X VGND VGND VPWR VPWR _8213_/D sky130_fd_sc_hd__a22o_1
X_8222_ _9053_/CLK _8222_/D VGND VGND VPWR VPWR _8222_/Q sky130_fd_sc_hd__dfxtp_1
X_5434_ _6798_/X VGND VGND VPWR VPWR _5434_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_99_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8153_ _8794_/CLK _8153_/D VGND VGND VPWR VPWR _8153_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_114_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7104_ _8515_/Q _8899_/Q _8835_/Q _8867_/Q _7179_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7104_/X sky130_fd_sc_hd__mux4_2
X_5365_ _8283_/Q _5357_/X _5144_/X _5360_/X VGND VGND VPWR VPWR _8283_/D sky130_fd_sc_hd__a22o_1
X_5296_ _8328_/Q _5291_/X _5190_/X _5292_/X VGND VGND VPWR VPWR _8328_/D sky130_fd_sc_hd__a22o_1
X_4316_ _4340_/A VGND VGND VPWR VPWR _4316_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_87_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8084_ _9044_/CLK _8084_/D VGND VGND VPWR VPWR _8084_/Q sky130_fd_sc_hd__dfxtp_1
X_4247_ _8938_/Q _4244_/X _4070_/X _4245_/X VGND VGND VPWR VPWR _8938_/D sky130_fd_sc_hd__a22o_1
XFILLER_87_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7035_ _7796_/X _7801_/X _7059_/S VGND VGND VPWR VPWR _7035_/X sky130_fd_sc_hd__mux2_1
XFILLER_19_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4178_ _4178_/A VGND VGND VPWR VPWR _4178_/X sky130_fd_sc_hd__buf_2
XFILLER_95_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8986_ _8986_/CLK _8986_/D VGND VGND VPWR VPWR _8986_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_28_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7937_ _8604_/Q _8156_/Q _8508_/Q _8796_/Q _8000_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7937_/X sky130_fd_sc_hd__mux4_2
XFILLER_83_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7868_ _8280_/Q _8248_/Q _8216_/Q _9016_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7868_/X sky130_fd_sc_hd__mux4_1
XPHY_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6819_ _6588_/X _7054_/X _6830_/S VGND VGND VPWR VPWR _6819_/X sky130_fd_sc_hd__mux2_1
XFILLER_11_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7799_ _8117_/Q _8085_/Q _8053_/Q _9045_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7799_/X sky130_fd_sc_hd__mux4_1
XPHY_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5150_ _6803_/X VGND VGND VPWR VPWR _5150_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5081_ _8449_/Q _5053_/A _4934_/X _5054_/A VGND VGND VPWR VPWR _8449_/D sky130_fd_sc_hd__a22o_1
X_4101_ _9025_/Q _4085_/X _4100_/X _4088_/X VGND VGND VPWR VPWR _9025_/D sky130_fd_sc_hd__a22o_1
Xclkbuf_1_1_0_clk clkbuf_0_clk/X VGND VGND VPWR VPWR clkbuf_2_3_0_clk/A sky130_fd_sc_hd__clkbuf_1
X_4032_ _4614_/A VGND VGND VPWR VPWR _4032_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_37_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8840_ _8929_/CLK _8840_/D VGND VGND VPWR VPWR _8840_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_65_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8771_ _8934_/CLK _8771_/D VGND VGND VPWR VPWR _8771_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_65_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5983_ _7042_/X _5979_/X _5982_/A _6073_/A _5982_/Y VGND VGND VPWR VPWR _5993_/C
+ sky130_fd_sc_hd__a221o_1
XFILLER_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4934_ _6779_/X VGND VGND VPWR VPWR _4934_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_52_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7722_ _8817_/Q _8337_/Q _8945_/Q _8465_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7722_/X sky130_fd_sc_hd__mux4_1
XANTENNA_12 _5074_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4865_ _8575_/Q _4861_/X _4668_/X _4864_/X VGND VGND VPWR VPWR _8575_/D sky130_fd_sc_hd__a22o_1
X_7653_ _8430_/Q _8302_/Q _8366_/Q _8558_/Q _7655_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7653_/X sky130_fd_sc_hd__mux4_1
XFILLER_20_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_23 _6460_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4796_ _8619_/Q _4794_/X _4638_/X _4795_/X VGND VGND VPWR VPWR _8619_/D sky130_fd_sc_hd__a22o_1
X_7584_ _8522_/Q _8906_/Q _8842_/Q _8874_/Q input8/X _7985_/S1 VGND VGND VPWR VPWR
+ _7584_/X sky130_fd_sc_hd__mux4_1
XANTENNA_56 _9063_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_45 _9071_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6604_ _6604_/A VGND VGND VPWR VPWR _6604_/X sky130_fd_sc_hd__clkbuf_2
XANTENNA_34 _6604_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6535_ _6514_/Y _6524_/Y _5886_/Y _6534_/X VGND VGND VPWR VPWR _6614_/A sky130_fd_sc_hd__a31o_2
XFILLER_137_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6466_ _6467_/B VGND VGND VPWR VPWR _6466_/Y sky130_fd_sc_hd__inv_2
X_8205_ _9038_/CLK _8205_/D VGND VGND VPWR VPWR _8205_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_134_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5417_ _8251_/Q _5405_/X _5416_/X _5408_/X VGND VGND VPWR VPWR _8251_/D sky130_fd_sc_hd__a22o_1
X_6397_ _6304_/Y _6396_/A _6304_/A _6396_/Y VGND VGND VPWR VPWR _6397_/X sky130_fd_sc_hd__o22a_1
X_5348_ _8294_/Q _5346_/X _5195_/X _5347_/X VGND VGND VPWR VPWR _8294_/D sky130_fd_sc_hd__a22o_1
XFILLER_114_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8136_ _9056_/CLK _8136_/D VGND VGND VPWR VPWR _8136_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_102_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8067_ _9027_/CLK _8067_/D VGND VGND VPWR VPWR _8067_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_48_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5279_ _8341_/Q _5277_/X _5159_/X _5278_/X VGND VGND VPWR VPWR _8341_/D sky130_fd_sc_hd__a22o_1
X_7018_ _6632_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7018_/X sky130_fd_sc_hd__mux2_4
XFILLER_46_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8969_ _9033_/CLK _8969_/D VGND VGND VPWR VPWR _8969_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_102_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4650_ _4650_/A VGND VGND VPWR VPWR _4650_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_30_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput10 imData[18] VGND VGND VPWR VPWR input10/X sky130_fd_sc_hd__buf_4
Xinput21 imData[28] VGND VGND VPWR VPWR _3985_/A sky130_fd_sc_hd__buf_4
XFILLER_128_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4581_ _8739_/Q _4576_/X _4382_/X _4577_/X VGND VGND VPWR VPWR _8739_/D sky130_fd_sc_hd__a22o_1
Xinput32 imData[9] VGND VGND VPWR VPWR _6949_/S sky130_fd_sc_hd__buf_6
X_6320_ _6321_/B VGND VGND VPWR VPWR _6320_/Y sky130_fd_sc_hd__inv_2
XFILLER_6_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6251_ _6251_/A _6253_/A VGND VGND VPWR VPWR _6251_/X sky130_fd_sc_hd__or2_2
XFILLER_6_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5202_ _6781_/X VGND VGND VPWR VPWR _5202_/X sky130_fd_sc_hd__clkbuf_2
X_6182_ _6178_/X _6180_/Y _6181_/X VGND VGND VPWR VPWR _6182_/Y sky130_fd_sc_hd__o21ai_2
X_5133_ _5158_/A VGND VGND VPWR VPWR _5133_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_111_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5064_ _8462_/Q _5060_/X _4904_/X _5061_/X VGND VGND VPWR VPWR _8462_/D sky130_fd_sc_hd__a22o_1
X_4015_ _4602_/A VGND VGND VPWR VPWR _4015_/X sky130_fd_sc_hd__buf_2
XFILLER_38_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8823_ _8953_/CLK _8823_/D VGND VGND VPWR VPWR _8823_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_37_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5966_ _6437_/A _5963_/Y _7060_/X _6471_/B VGND VGND VPWR VPWR _5993_/A sky130_fd_sc_hd__a22o_1
X_8754_ _8786_/CLK _8754_/D VGND VGND VPWR VPWR _8754_/Q sky130_fd_sc_hd__dfxtp_1
X_4917_ _8553_/Q _4910_/X _4916_/X _4912_/X VGND VGND VPWR VPWR _8553_/D sky130_fd_sc_hd__a22o_1
X_8685_ _8877_/CLK _8685_/D VGND VGND VPWR VPWR _8685_/Q sky130_fd_sc_hd__dfxtp_1
X_5897_ _6971_/S _5897_/B VGND VGND VPWR VPWR _5899_/B sky130_fd_sc_hd__or2_1
X_7705_ _8720_/Q _8688_/Q _8656_/Q _8624_/Q _7710_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7705_/X sky130_fd_sc_hd__mux4_2
X_4848_ _8583_/Q _4842_/X _4647_/X _4843_/X VGND VGND VPWR VPWR _8583_/D sky130_fd_sc_hd__a22o_1
X_7636_ _7632_/X _7633_/X _7634_/X _7635_/X _7701_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7636_/X sky130_fd_sc_hd__mux4_2
XFILLER_20_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7567_ _8585_/Q _8137_/Q _8489_/Q _8777_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7567_/X sky130_fd_sc_hd__mux4_1
XFILLER_20_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4779_ _8630_/Q _4773_/X _4611_/X _4774_/X VGND VGND VPWR VPWR _8630_/D sky130_fd_sc_hd__a22o_1
XFILLER_107_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7498_ _8262_/Q _8230_/Q _8198_/Q _8998_/Q _7500_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7498_/X sky130_fd_sc_hd__mux4_1
X_6518_ _6518_/A VGND VGND VPWR VPWR _6673_/B sky130_fd_sc_hd__inv_2
XFILLER_134_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6449_ _7033_/X VGND VGND VPWR VPWR _6457_/A sky130_fd_sc_hd__inv_2
XFILLER_0_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8119_ _9080_/CLK _8119_/D VGND VGND VPWR VPWR _8119_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_102_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5820_ _5820_/A VGND VGND VPWR VPWR _5947_/B sky130_fd_sc_hd__clkbuf_2
X_5751_ _8047_/Q _5748_/X _4629_/A _5749_/X VGND VGND VPWR VPWR _8047_/D sky130_fd_sc_hd__a22o_1
X_4702_ _8681_/Q _4698_/X _4643_/X _4699_/X VGND VGND VPWR VPWR _8681_/D sky130_fd_sc_hd__a22o_1
XFILLER_15_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8470_ _8822_/CLK _8470_/D VGND VGND VPWR VPWR _8470_/Q sky130_fd_sc_hd__dfxtp_1
X_7421_ _7417_/X _7418_/X _7419_/X _7420_/X _7501_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7421_/X sky130_fd_sc_hd__mux4_1
X_5682_ _8094_/Q _5677_/X _4593_/A _5680_/X VGND VGND VPWR VPWR _8094_/D sky130_fd_sc_hd__a22o_1
XFILLER_30_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4633_ _4633_/A VGND VGND VPWR VPWR _4633_/X sky130_fd_sc_hd__clkbuf_2
X_7352_ _8828_/Q _8348_/Q _8956_/Q _8476_/Q _6343_/A _6344_/B VGND VGND VPWR VPWR
+ _7352_/X sky130_fd_sc_hd__mux4_1
X_4564_ _8752_/Q _4562_/X _4351_/X _4563_/X VGND VGND VPWR VPWR _8752_/D sky130_fd_sc_hd__a22o_1
X_6303_ _6269_/Y _6401_/A _6402_/A _6302_/X VGND VGND VPWR VPWR _6304_/A sky130_fd_sc_hd__a31o_1
X_7283_ _8437_/Q _8309_/Q _8373_/Q _8565_/Q _7369_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7283_/X sky130_fd_sc_hd__mux4_1
XFILLER_131_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4495_ _8799_/Q _4491_/X _4393_/X _4494_/X VGND VGND VPWR VPWR _8799_/D sky130_fd_sc_hd__a22o_1
X_9022_ _9055_/CLK _9022_/D VGND VGND VPWR VPWR _9022_/Q sky130_fd_sc_hd__dfxtp_1
X_6234_ _6234_/A _6234_/B VGND VGND VPWR VPWR _6234_/Y sky130_fd_sc_hd__nor2_4
X_6165_ _9083_/Q _6165_/B VGND VGND VPWR VPWR _6166_/A sky130_fd_sc_hd__nand2_1
X_5116_ _5123_/A VGND VGND VPWR VPWR _5116_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_85_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6096_ _7022_/S VGND VGND VPWR VPWR _6096_/Y sky130_fd_sc_hd__inv_2
XFILLER_84_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5047_ _5054_/A VGND VGND VPWR VPWR _5047_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_27_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8806_ _8868_/CLK _8806_/D VGND VGND VPWR VPWR _8806_/Q sky130_fd_sc_hd__dfxtp_1
X_6998_ _7546_/X _7551_/X _7067_/S VGND VGND VPWR VPWR _6998_/X sky130_fd_sc_hd__mux2_1
X_5949_ _5943_/A _5859_/B _5860_/B VGND VGND VPWR VPWR _5949_/Y sky130_fd_sc_hd__o21ai_1
X_8737_ _8929_/CLK _8737_/D VGND VGND VPWR VPWR _8737_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8668_ _8735_/CLK _8668_/D VGND VGND VPWR VPWR _8668_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_138_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7619_ _8108_/Q _8076_/Q _8044_/Q _9036_/Q _7659_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7619_/X sky130_fd_sc_hd__mux4_1
X_8599_ _8951_/CLK _8599_/D VGND VGND VPWR VPWR _8599_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_107_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4280_ _8918_/Q _4274_/X _4029_/X _4275_/X VGND VGND VPWR VPWR _8918_/D sky130_fd_sc_hd__a22o_1
XFILLER_98_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7970_ _8989_/Q _8413_/Q _8189_/Q _8765_/Q _7990_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7970_/X sky130_fd_sc_hd__mux4_1
XFILLER_66_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6921_ _7060_/X _7063_/X _6963_/S VGND VGND VPWR VPWR _6921_/X sky130_fd_sc_hd__mux2_1
XFILLER_62_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6852_ _6964_/X _6957_/X _6949_/S VGND VGND VPWR VPWR _6852_/X sky130_fd_sc_hd__mux2_1
XFILLER_50_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5803_ _6875_/X _5800_/A _6882_/X _5920_/B VGND VGND VPWR VPWR _5803_/X sky130_fd_sc_hd__a22o_1
XFILLER_62_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8522_ _8907_/CLK _8522_/D VGND VGND VPWR VPWR _8522_/Q sky130_fd_sc_hd__dfxtp_1
X_6783_ _5915_/Y _5925_/X _6809_/S VGND VGND VPWR VPWR _6783_/X sky130_fd_sc_hd__mux2_4
X_3995_ _6810_/X _6811_/X _4488_/C VGND VGND VPWR VPWR _5723_/A sky130_fd_sc_hd__or3_4
XFILLER_22_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5734_ _5741_/A VGND VGND VPWR VPWR _5734_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_129_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8453_ _8869_/CLK _8453_/D VGND VGND VPWR VPWR _8453_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_108_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5665_ _8103_/Q _5659_/X _5464_/X _5660_/X VGND VGND VPWR VPWR _8103_/D sky130_fd_sc_hd__a22o_1
XFILLER_30_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7404_ _8513_/Q _8897_/Q _8833_/Q _8865_/Q _7550_/S0 _7604_/S1 VGND VGND VPWR VPWR
+ _7404_/X sky130_fd_sc_hd__mux4_1
X_4616_ _8725_/Q _4613_/X _4614_/X _4615_/X VGND VGND VPWR VPWR _8725_/D sky130_fd_sc_hd__a22o_1
X_8384_ _8928_/CLK _8384_/D VGND VGND VPWR VPWR _8384_/Q sky130_fd_sc_hd__dfxtp_1
X_7335_ _8730_/Q _8698_/Q _8666_/Q _8634_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7335_/X sky130_fd_sc_hd__mux4_2
X_5596_ _8150_/Q _5590_/X _5428_/X _5591_/X VGND VGND VPWR VPWR _8150_/D sky130_fd_sc_hd__a22o_1
X_4547_ _8763_/Q _4539_/X _4324_/X _4542_/X VGND VGND VPWR VPWR _8763_/D sky130_fd_sc_hd__a22o_1
X_4478_ _8807_/Q _4472_/X _4372_/X _4473_/X VGND VGND VPWR VPWR _8807_/D sky130_fd_sc_hd__a22o_1
XFILLER_104_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7266_ _7262_/X _7263_/X _7264_/X _7265_/X _7291_/S0 input36/X VGND VGND VPWR VPWR
+ _7266_/X sky130_fd_sc_hd__mux4_2
X_7197_ _8588_/Q _8140_/Q _8492_/Q _8780_/Q _7229_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7197_/X sky130_fd_sc_hd__mux4_1
X_9005_ _9038_/CLK _9005_/D VGND VGND VPWR VPWR _9005_/Q sky130_fd_sc_hd__dfxtp_1
X_6217_ _6217_/A _6217_/B VGND VGND VPWR VPWR _6217_/X sky130_fd_sc_hd__or2_2
X_6148_ _6148_/A VGND VGND VPWR VPWR _6149_/B sky130_fd_sc_hd__inv_2
XFILLER_38_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6079_ _5908_/A _5795_/A _5947_/A _5819_/A _6060_/X VGND VGND VPWR VPWR _6084_/A
+ sky130_fd_sc_hd__a221o_1
Xrepeater271 _6098_/A VGND VGND VPWR VPWR _7711_/S0 sky130_fd_sc_hd__buf_8
XFILLER_72_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrepeater260 input14/X VGND VGND VPWR VPWR _7894_/S0 sky130_fd_sc_hd__buf_8
XFILLER_38_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5450_ _6791_/X VGND VGND VPWR VPWR _5450_/X sky130_fd_sc_hd__clkbuf_2
X_4401_ _8859_/Q _4392_/X _4324_/X _4396_/X VGND VGND VPWR VPWR _8859_/D sky130_fd_sc_hd__a22o_1
XFILLER_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5381_ _5395_/A VGND VGND VPWR VPWR _5381_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_126_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7120_ _8964_/Q _8388_/Q _8164_/Q _8740_/Q _7140_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7120_/X sky130_fd_sc_hd__mux4_1
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4332_ _4607_/A VGND VGND VPWR VPWR _4332_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_87_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4263_ _4938_/B _5579_/A VGND VGND VPWR VPWR _4302_/A sky130_fd_sc_hd__or2_4
X_7051_ _6377_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7051_/X sky130_fd_sc_hd__mux2_2
Xclkbuf_4_7_0_clk clkbuf_4_7_0_clk/A VGND VGND VPWR VPWR clkbuf_4_7_0_clk/X sky130_fd_sc_hd__clkbuf_1
X_6002_ _6491_/B VGND VGND VPWR VPWR _6002_/X sky130_fd_sc_hd__dlymetal6s2s_1
X_4194_ _8971_/Q _4192_/X _4066_/X _4193_/X VGND VGND VPWR VPWR _8971_/D sky130_fd_sc_hd__a22o_1
XFILLER_27_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7953_ _8445_/Q _8317_/Q _8381_/Q _8573_/Q _7995_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7953_/X sky130_fd_sc_hd__mux4_1
XFILLER_82_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6904_ _6955_/X _6953_/X _6961_/S VGND VGND VPWR VPWR _6904_/X sky130_fd_sc_hd__mux2_1
X_7884_ _8537_/Q _8921_/Q _8857_/Q _8889_/Q _7907_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7884_/X sky130_fd_sc_hd__mux4_1
XPHY_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6835_ _6834_/X _6434_/X _6948_/S VGND VGND VPWR VPWR _6835_/X sky130_fd_sc_hd__mux2_1
XFILLER_24_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3978_ _3989_/A _3988_/B _3982_/C _3978_/D VGND VGND VPWR VPWR _3979_/D sky130_fd_sc_hd__or4_4
XFILLER_50_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6766_ _6367_/Y _6207_/Y _6777_/S VGND VGND VPWR VPWR _9076_/D sky130_fd_sc_hd__mux2_1
X_5717_ _8069_/Q _5714_/X _4653_/A _5715_/X VGND VGND VPWR VPWR _8069_/D sky130_fd_sc_hd__a22o_1
XFILLER_50_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8505_ _8922_/CLK _8505_/D VGND VGND VPWR VPWR _8505_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_109_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6697_ _6696_/X _9063_/Q _6705_/S VGND VGND VPWR VPWR _6697_/X sky130_fd_sc_hd__mux2_2
X_8436_ _8882_/CLK _8436_/D VGND VGND VPWR VPWR _8436_/Q sky130_fd_sc_hd__dfxtp_1
X_5648_ _8116_/Q _5645_/X _5434_/X _5646_/X VGND VGND VPWR VPWR _8116_/D sky130_fd_sc_hd__a22o_1
XFILLER_117_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5579_ _5579_/A _5579_/B VGND VGND VPWR VPWR _5618_/A sky130_fd_sc_hd__or2_4
X_8367_ _8943_/CLK _8367_/D VGND VGND VPWR VPWR _8367_/Q sky130_fd_sc_hd__dfxtp_1
X_8298_ _8841_/CLK _8298_/D VGND VGND VPWR VPWR _8298_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_105_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7318_ _8280_/Q _8248_/Q _8216_/Q _9016_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7318_/X sky130_fd_sc_hd__mux4_1
X_7249_ _8113_/Q _8081_/Q _8049_/Q _9041_/Q _7280_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7249_/X sky130_fd_sc_hd__mux4_1
XFILLER_131_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_107_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput8 imData[16] VGND VGND VPWR VPWR input8/X sky130_fd_sc_hd__clkbuf_4
XFILLER_39_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4950_ _4957_/A VGND VGND VPWR VPWR _4950_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_17_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4881_ _8568_/Q _4874_/X _4880_/X _4876_/X VGND VGND VPWR VPWR _8568_/D sky130_fd_sc_hd__a22o_1
X_6620_ _6620_/A VGND VGND VPWR VPWR _6620_/X sky130_fd_sc_hd__buf_2
X_6551_ _6476_/Y _5968_/A _6478_/X _6485_/X _6550_/X VGND VGND VPWR VPWR _6582_/A
+ sky130_fd_sc_hd__o2111a_1
XFILLER_9_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5502_ _5502_/A VGND VGND VPWR VPWR _5502_/X sky130_fd_sc_hd__buf_2
XFILLER_118_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6482_ _6482_/A VGND VGND VPWR VPWR _6482_/X sky130_fd_sc_hd__buf_1
XFILLER_133_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8221_ _9053_/CLK _8221_/D VGND VGND VPWR VPWR _8221_/Q sky130_fd_sc_hd__dfxtp_1
X_5433_ _8245_/Q _5430_/X _5431_/X _5432_/X VGND VGND VPWR VPWR _8245_/D sky130_fd_sc_hd__a22o_1
XFILLER_133_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5364_ _8284_/Q _5357_/X _5142_/X _5360_/X VGND VGND VPWR VPWR _8284_/D sky130_fd_sc_hd__a22o_1
X_8152_ _8952_/CLK _8152_/D VGND VGND VPWR VPWR _8152_/Q sky130_fd_sc_hd__dfxtp_1
X_7103_ _8419_/Q _8291_/Q _8355_/Q _8547_/Q _7179_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7103_/X sky130_fd_sc_hd__mux4_1
X_4315_ _4376_/A VGND VGND VPWR VPWR _4340_/A sky130_fd_sc_hd__clkbuf_4
X_5295_ _8329_/Q _5291_/X _5188_/X _5292_/X VGND VGND VPWR VPWR _8329_/D sky130_fd_sc_hd__a22o_1
XFILLER_99_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8083_ _9044_/CLK _8083_/D VGND VGND VPWR VPWR _8083_/Q sky130_fd_sc_hd__dfxtp_1
X_4246_ _8939_/Q _4244_/X _4066_/X _4245_/X VGND VGND VPWR VPWR _8939_/D sky130_fd_sc_hd__a22o_1
X_7034_ _7786_/X _7791_/X _7070_/S VGND VGND VPWR VPWR _7034_/X sky130_fd_sc_hd__mux2_1
X_4177_ _8982_/Q _4171_/X _4029_/X _4172_/X VGND VGND VPWR VPWR _8982_/D sky130_fd_sc_hd__a22o_1
XFILLER_83_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8985_ _9049_/CLK _8985_/D VGND VGND VPWR VPWR _8985_/Q sky130_fd_sc_hd__dfxtp_1
X_7936_ _7932_/X _7933_/X _7934_/X _7935_/X _7996_/S0 _5771_/B VGND VGND VPWR VPWR
+ _7936_/X sky130_fd_sc_hd__mux4_2
XFILLER_70_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7867_ _8600_/Q _8152_/Q _8504_/Q _8792_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7867_/X sky130_fd_sc_hd__mux4_1
XFILLER_35_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6818_ _6581_/X _7057_/X _6830_/S VGND VGND VPWR VPWR _6818_/X sky130_fd_sc_hd__mux2_2
XPHY_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7798_ _8277_/Q _8245_/Q _8213_/Q _9013_/Q _7798_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7798_/X sky130_fd_sc_hd__mux4_2
X_6749_ _6417_/X _6284_/B _6777_/S VGND VGND VPWR VPWR _9059_/D sky130_fd_sc_hd__mux2_1
XPHY_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8419_ _9034_/CLK _8419_/D VGND VGND VPWR VPWR _8419_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_136_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5080_ _8450_/Q _5074_/X _4932_/X _5075_/X VGND VGND VPWR VPWR _8450_/D sky130_fd_sc_hd__a22o_1
XFILLER_110_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4100_ _4661_/A VGND VGND VPWR VPWR _4100_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_69_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4031_ _6799_/X VGND VGND VPWR VPWR _4614_/A sky130_fd_sc_hd__buf_1
X_8770_ _8933_/CLK _8770_/D VGND VGND VPWR VPWR _8770_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_92_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5982_ _5982_/A _6073_/A VGND VGND VPWR VPWR _5982_/Y sky130_fd_sc_hd__nor2_1
XFILLER_18_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4933_ _8546_/Q _4922_/X _4932_/X _4924_/X VGND VGND VPWR VPWR _8546_/D sky130_fd_sc_hd__a22o_1
XFILLER_52_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7721_ _7717_/X _7718_/X _7719_/X _7720_/X _7801_/S0 input17/X VGND VGND VPWR VPWR
+ _7721_/X sky130_fd_sc_hd__mux4_2
XFILLER_80_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_13 _5122_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4864_ _4888_/A VGND VGND VPWR VPWR _4864_/X sky130_fd_sc_hd__clkbuf_2
X_7652_ _8814_/Q _8334_/Q _8942_/Q _8462_/Q _7655_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7652_/X sky130_fd_sc_hd__mux4_1
XFILLER_32_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_57 _6727_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4795_ _4802_/A VGND VGND VPWR VPWR _4795_/X sky130_fd_sc_hd__clkbuf_2
XANTENNA_46 _9074_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7583_ _8426_/Q _8298_/Q _8362_/Q _8554_/Q _7604_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7583_/X sky130_fd_sc_hd__mux4_2
XANTENNA_35 _6666_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_24 _6031_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6603_ _6550_/A _6602_/A _6487_/A _6602_/Y VGND VGND VPWR VPWR _6603_/X sky130_fd_sc_hd__o22a_1
X_6534_ _6833_/X _6658_/B _6532_/X _6533_/X VGND VGND VPWR VPWR _6534_/X sky130_fd_sc_hd__o22a_1
XFILLER_119_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6465_ _6465_/A _6465_/B VGND VGND VPWR VPWR _6467_/B sky130_fd_sc_hd__or2_1
XFILLER_137_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8204_ _8236_/CLK _8204_/D VGND VGND VPWR VPWR _8204_/Q sky130_fd_sc_hd__dfxtp_1
X_5416_ _6805_/X VGND VGND VPWR VPWR _5416_/X sky130_fd_sc_hd__clkbuf_2
X_6396_ _6396_/A VGND VGND VPWR VPWR _6396_/Y sky130_fd_sc_hd__inv_2
X_5347_ _5347_/A VGND VGND VPWR VPWR _5347_/X sky130_fd_sc_hd__buf_2
X_8135_ _8939_/CLK _8135_/D VGND VGND VPWR VPWR _8135_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_99_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8066_ _9029_/CLK _8066_/D VGND VGND VPWR VPWR _8066_/Q sky130_fd_sc_hd__dfxtp_1
X_5278_ _5278_/A VGND VGND VPWR VPWR _5278_/X sky130_fd_sc_hd__buf_2
X_4229_ _8950_/Q _4223_/X _4029_/X _4224_/X VGND VGND VPWR VPWR _8950_/D sky130_fd_sc_hd__a22o_1
X_7017_ _7676_/X _7681_/X _7020_/S VGND VGND VPWR VPWR _7017_/X sky130_fd_sc_hd__mux2_2
XFILLER_46_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8968_ _9061_/CLK _8968_/D VGND VGND VPWR VPWR _8968_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_71_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7919_ _8123_/Q _8091_/Q _8059_/Q _9051_/Q _7919_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7919_/X sky130_fd_sc_hd__mux4_1
XPHY_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8899_ _8932_/CLK _8899_/D VGND VGND VPWR VPWR _8899_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_129_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_120_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4580_ _8740_/Q _4576_/X _4380_/X _4577_/X VGND VGND VPWR VPWR _8740_/D sky130_fd_sc_hd__a22o_1
Xinput22 imData[29] VGND VGND VPWR VPWR _5955_/D sky130_fd_sc_hd__buf_2
Xinput11 imData[19] VGND VGND VPWR VPWR input11/X sky130_fd_sc_hd__buf_8
XPHY_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput33 regAddr[0] VGND VGND VPWR VPWR input33/X sky130_fd_sc_hd__clkbuf_2
X_6250_ _6246_/A _6246_/B _6246_/X VGND VGND VPWR VPWR _6253_/A sky130_fd_sc_hd__a21bo_1
X_5201_ _8388_/Q _5194_/X _5200_/X _5196_/X VGND VGND VPWR VPWR _8388_/D sky130_fd_sc_hd__a22o_1
X_6181_ _6185_/A _6181_/B VGND VGND VPWR VPWR _6181_/X sky130_fd_sc_hd__or2_2
XFILLER_97_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5132_ _5194_/A VGND VGND VPWR VPWR _5158_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_84_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5063_ _8463_/Q _5060_/X _4902_/X _5061_/X VGND VGND VPWR VPWR _8463_/D sky130_fd_sc_hd__a22o_1
X_4014_ _6804_/X VGND VGND VPWR VPWR _4602_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_52_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8822_ _8822_/CLK _8822_/D VGND VGND VPWR VPWR _8822_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5965_ _5965_/A VGND VGND VPWR VPWR _6471_/B sky130_fd_sc_hd__buf_1
X_8753_ _9050_/CLK _8753_/D VGND VGND VPWR VPWR _8753_/Q sky130_fd_sc_hd__dfxtp_1
X_4916_ _6787_/X VGND VGND VPWR VPWR _4916_/X sky130_fd_sc_hd__clkbuf_2
X_8684_ _8876_/CLK _8684_/D VGND VGND VPWR VPWR _8684_/Q sky130_fd_sc_hd__dfxtp_1
X_5896_ _6963_/S _7066_/X VGND VGND VPWR VPWR _5897_/B sky130_fd_sc_hd__or2_1
X_7704_ _8528_/Q _8912_/Q _8848_/Q _8880_/Q _7710_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7704_/X sky130_fd_sc_hd__mux4_1
XFILLER_40_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4847_ _8584_/Q _4842_/X _4645_/X _4843_/X VGND VGND VPWR VPWR _8584_/D sky130_fd_sc_hd__a22o_1
X_7635_ _8717_/Q _8685_/Q _8653_/Q _8621_/Q _7655_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7635_/X sky130_fd_sc_hd__mux4_2
XFILLER_33_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7566_ _7562_/X _7563_/X _7564_/X _7565_/X _8006_/S0 _7611_/S1 VGND VGND VPWR VPWR
+ _7566_/X sky130_fd_sc_hd__mux4_2
X_4778_ _8631_/Q _4773_/X _4609_/X _4774_/X VGND VGND VPWR VPWR _8631_/D sky130_fd_sc_hd__a22o_1
XFILLER_119_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7497_ _8582_/Q _8134_/Q _8486_/Q _8774_/Q _7500_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7497_/X sky130_fd_sc_hd__mux4_2
X_6517_ _6833_/X _6658_/B _6833_/X _6031_/A VGND VGND VPWR VPWR _6524_/B sky130_fd_sc_hd__a2bb2o_1
X_6448_ _7036_/X VGND VGND VPWR VPWR _6458_/A sky130_fd_sc_hd__inv_2
XFILLER_134_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6379_ _6379_/A VGND VGND VPWR VPWR _6379_/Y sky130_fd_sc_hd__inv_2
X_8118_ _9048_/CLK _8118_/D VGND VGND VPWR VPWR _8118_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_130_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8049_ _8981_/CLK _8049_/D VGND VGND VPWR VPWR _8049_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_56_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_1_0_0_clk clkbuf_0_clk/X VGND VGND VPWR VPWR clkbuf_2_1_0_clk/A sky130_fd_sc_hd__clkbuf_1
XPHY_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_100_clk clkbuf_opt_0_clk/A VGND VGND VPWR VPWR _9069_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_98_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5750_ _8048_/Q _5748_/X _4626_/A _5749_/X VGND VGND VPWR VPWR _8048_/D sky130_fd_sc_hd__a22o_1
XFILLER_43_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4701_ _8682_/Q _4698_/X _4641_/X _4699_/X VGND VGND VPWR VPWR _8682_/D sky130_fd_sc_hd__a22o_1
X_5681_ _8095_/Q _5677_/X _5485_/X _5680_/X VGND VGND VPWR VPWR _8095_/D sky130_fd_sc_hd__a22o_1
X_7420_ _8962_/Q _8386_/Q _8162_/Q _8738_/Q _7480_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7420_/X sky130_fd_sc_hd__mux4_1
X_4632_ _8718_/Q _4625_/X _4631_/X _4627_/X VGND VGND VPWR VPWR _8718_/D sky130_fd_sc_hd__a22o_1
XFILLER_128_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4563_ _4577_/A VGND VGND VPWR VPWR _4563_/X sky130_fd_sc_hd__clkbuf_2
X_7351_ _7347_/X _7348_/X _7349_/X _7350_/X _7391_/S0 input36/X VGND VGND VPWR VPWR
+ _7351_/X sky130_fd_sc_hd__mux4_2
X_6302_ _6269_/Y _6401_/A _6402_/B _6301_/Y VGND VGND VPWR VPWR _6302_/X sky130_fd_sc_hd__a31o_1
X_4494_ _4508_/A VGND VGND VPWR VPWR _4494_/X sky130_fd_sc_hd__clkbuf_2
X_7282_ _8821_/Q _8341_/Q _8949_/Q _8469_/Q _7369_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7282_/X sky130_fd_sc_hd__mux4_1
XFILLER_104_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9021_ _9053_/CLK _9021_/D VGND VGND VPWR VPWR _9021_/Q sky130_fd_sc_hd__dfxtp_1
X_6233_ input6/X _6230_/Y _6232_/X VGND VGND VPWR VPWR _6311_/B sky130_fd_sc_hd__o21ai_2
X_6164_ _6164_/A VGND VGND VPWR VPWR _6165_/B sky130_fd_sc_hd__inv_2
X_5115_ _5122_/A VGND VGND VPWR VPWR _5115_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_57_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6095_ _6948_/S VGND VGND VPWR VPWR _6251_/A sky130_fd_sc_hd__inv_2
XFILLER_73_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5046_ _5053_/A VGND VGND VPWR VPWR _5046_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_38_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8805_ _8869_/CLK _8805_/D VGND VGND VPWR VPWR _8805_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6997_ _5911_/Y _5903_/Y _7069_/S VGND VGND VPWR VPWR _6997_/X sky130_fd_sc_hd__mux2_4
XFILLER_13_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5948_ _6917_/X _5946_/X _5913_/X _5947_/Y VGND VGND VPWR VPWR _5948_/Y sky130_fd_sc_hd__o22ai_2
X_8736_ _8960_/CLK _8736_/D VGND VGND VPWR VPWR _8736_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_53_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8667_ _8735_/CLK _8667_/D VGND VGND VPWR VPWR _8667_/Q sky130_fd_sc_hd__dfxtp_1
X_5879_ _6513_/A _5878_/X _6513_/A _5878_/X VGND VGND VPWR VPWR _5879_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_139_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7618_ _8268_/Q _8236_/Q _8204_/Q _9004_/Q _7659_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7618_/X sky130_fd_sc_hd__mux4_1
X_8598_ _8790_/CLK _8598_/D VGND VGND VPWR VPWR _8598_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_107_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7549_ _8104_/Q _8072_/Q _8040_/Q _9032_/Q _7550_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7549_/X sky130_fd_sc_hd__mux4_2
XFILLER_5_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6920_ _6921_/X _5897_/B _6971_/S VGND VGND VPWR VPWR _6920_/X sky130_fd_sc_hd__mux2_1
X_6851_ _5877_/X _7000_/X _6943_/S VGND VGND VPWR VPWR _6851_/X sky130_fd_sc_hd__mux2_1
X_5802_ _5802_/A VGND VGND VPWR VPWR _5920_/B sky130_fd_sc_hd__inv_2
XFILLER_90_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8521_ _8841_/CLK _8521_/D VGND VGND VPWR VPWR _8521_/Q sky130_fd_sc_hd__dfxtp_1
X_6782_ _5921_/Y _5930_/X _6809_/S VGND VGND VPWR VPWR _6782_/X sky130_fd_sc_hd__mux2_2
X_3994_ _6812_/X VGND VGND VPWR VPWR _4488_/C sky130_fd_sc_hd__inv_2
X_5733_ _8059_/Q _5725_/X _4599_/A _5728_/X VGND VGND VPWR VPWR _8059_/D sky130_fd_sc_hd__a22o_1
X_8452_ _8868_/CLK _8452_/D VGND VGND VPWR VPWR _8452_/Q sky130_fd_sc_hd__dfxtp_1
X_5664_ _8104_/Q _5659_/X _5462_/X _5660_/X VGND VGND VPWR VPWR _8104_/D sky130_fd_sc_hd__a22o_1
XFILLER_135_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8383_ _8735_/CLK _8383_/D VGND VGND VPWR VPWR _8383_/Q sky130_fd_sc_hd__dfxtp_1
X_7403_ _8417_/Q _8289_/Q _8353_/Q _8545_/Q _7550_/S0 _7604_/S1 VGND VGND VPWR VPWR
+ _7403_/X sky130_fd_sc_hd__mux4_2
X_4615_ _4615_/A VGND VGND VPWR VPWR _4615_/X sky130_fd_sc_hd__clkbuf_2
X_5595_ _8151_/Q _5590_/X _5426_/X _5591_/X VGND VGND VPWR VPWR _8151_/D sky130_fd_sc_hd__a22o_1
XFILLER_135_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4546_ _8764_/Q _4539_/X _4322_/X _4542_/X VGND VGND VPWR VPWR _8764_/D sky130_fd_sc_hd__a22o_1
X_7334_ _8538_/Q _8922_/Q _8858_/Q _8890_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7334_/X sky130_fd_sc_hd__mux4_2
XFILLER_116_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4477_ _8808_/Q _4472_/X _4370_/X _4473_/X VGND VGND VPWR VPWR _8808_/D sky130_fd_sc_hd__a22o_1
X_7265_ _8723_/Q _8691_/Q _8659_/Q _8627_/Q _7359_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7265_/X sky130_fd_sc_hd__mux4_2
X_7196_ _7192_/X _7193_/X _7194_/X _7195_/X _7241_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7196_/X sky130_fd_sc_hd__mux4_1
X_9004_ _9004_/CLK _9004_/D VGND VGND VPWR VPWR _9004_/Q sky130_fd_sc_hd__dfxtp_1
X_6216_ _6217_/B VGND VGND VPWR VPWR _6216_/Y sky130_fd_sc_hd__inv_2
XFILLER_98_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6147_ _9072_/Q _6225_/A VGND VGND VPWR VPWR _6148_/A sky130_fd_sc_hd__nand2_1
XFILLER_38_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrepeater250 _7579_/S0 VGND VGND VPWR VPWR _7599_/S0 sky130_fd_sc_hd__clkbuf_8
XFILLER_85_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6078_ _6028_/B _6023_/X _6085_/C _6072_/X _6077_/X VGND VGND VPWR VPWR _6086_/C
+ sky130_fd_sc_hd__o221a_1
XFILLER_57_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater261 input14/X VGND VGND VPWR VPWR _7700_/S0 sky130_fd_sc_hd__buf_6
XFILLER_45_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5029_ _8485_/Q _5026_/X _4926_/X _5027_/X VGND VGND VPWR VPWR _8485_/D sky130_fd_sc_hd__a22o_1
Xrepeater272 _8011_/S0 VGND VGND VPWR VPWR _7811_/S0 sky130_fd_sc_hd__buf_8
XFILLER_54_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8719_ _8942_/CLK _8719_/D VGND VGND VPWR VPWR _8719_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4400_ _8860_/Q _4392_/X _4322_/X _4396_/X VGND VGND VPWR VPWR _8860_/D sky130_fd_sc_hd__a22o_1
X_5380_ _5394_/A VGND VGND VPWR VPWR _5380_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_125_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4331_ _8889_/Q _4326_/X _4330_/X _4328_/X VGND VGND VPWR VPWR _8889_/D sky130_fd_sc_hd__a22o_1
XFILLER_99_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4262_ _5675_/B VGND VGND VPWR VPWR _5579_/A sky130_fd_sc_hd__buf_1
X_7050_ _7896_/X _7901_/X _7059_/S VGND VGND VPWR VPWR _7050_/X sky130_fd_sc_hd__mux2_2
X_6001_ _7029_/X _6040_/B VGND VGND VPWR VPWR _6491_/B sky130_fd_sc_hd__and2_1
X_4193_ _4200_/A VGND VGND VPWR VPWR _4193_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_39_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7952_ _8829_/Q _8349_/Q _8957_/Q _8477_/Q _7995_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7952_/X sky130_fd_sc_hd__mux4_1
XFILLER_67_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6903_ _6904_/X _5906_/B _6964_/S VGND VGND VPWR VPWR _6903_/X sky130_fd_sc_hd__mux2_1
XFILLER_63_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7883_ _8441_/Q _8313_/Q _8377_/Q _8569_/Q _7907_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7883_/X sky130_fd_sc_hd__mux4_1
XFILLER_23_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6834_ _6867_/X _6866_/X _6949_/S VGND VGND VPWR VPWR _6834_/X sky130_fd_sc_hd__mux2_1
XFILLER_50_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3977_ _3981_/A _5953_/A _6284_/A input1/X VGND VGND VPWR VPWR _3978_/D sky130_fd_sc_hd__or4_4
XFILLER_50_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6765_ _6373_/Y _6203_/Y _6777_/S VGND VGND VPWR VPWR _9075_/D sky130_fd_sc_hd__mux2_1
X_5716_ _8070_/Q _5714_/X _4650_/A _5715_/X VGND VGND VPWR VPWR _8070_/D sky130_fd_sc_hd__a22o_1
X_8504_ _8952_/CLK _8504_/D VGND VGND VPWR VPWR _8504_/Q sky130_fd_sc_hd__dfxtp_1
X_6696_ _7146_/X _7151_/X _6704_/S VGND VGND VPWR VPWR _6696_/X sky130_fd_sc_hd__mux2_1
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8435_ _8786_/CLK _8435_/D VGND VGND VPWR VPWR _8435_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_136_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5647_ _8117_/Q _5645_/X _5431_/X _5646_/X VGND VGND VPWR VPWR _8117_/D sky130_fd_sc_hd__a22o_1
X_8366_ _8941_/CLK _8366_/D VGND VGND VPWR VPWR _8366_/Q sky130_fd_sc_hd__dfxtp_1
X_5578_ _8160_/Q _5549_/A _5480_/X _5550_/A VGND VGND VPWR VPWR _8160_/D sky130_fd_sc_hd__a22o_1
X_8297_ _8841_/CLK _8297_/D VGND VGND VPWR VPWR _8297_/Q sky130_fd_sc_hd__dfxtp_1
X_4529_ _4529_/A VGND VGND VPWR VPWR _4529_/X sky130_fd_sc_hd__clkbuf_2
X_7317_ _8600_/Q _8152_/Q _8504_/Q _8792_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7317_/X sky130_fd_sc_hd__mux4_1
XFILLER_132_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7248_ _8273_/Q _8241_/Q _8209_/Q _9009_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7248_/X sky130_fd_sc_hd__mux4_2
XFILLER_104_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7179_ _8106_/Q _8074_/Q _8042_/Q _9034_/Q _7179_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7179_/X sky130_fd_sc_hd__mux4_1
XFILLER_105_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_80_clk clkbuf_4_11_0_clk/X VGND VGND VPWR VPWR _8781_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_53_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput9 imData[17] VGND VGND VPWR VPWR input9/X sky130_fd_sc_hd__clkbuf_8
XFILLER_92_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_71_clk _9063_/CLK VGND VGND VPWR VPWR _9062_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_72_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4880_ _6802_/X VGND VGND VPWR VPWR _4880_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_32_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6550_ _6550_/A _6550_/B _6550_/C _6550_/D VGND VGND VPWR VPWR _6550_/X sky130_fd_sc_hd__or4_4
XFILLER_20_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5501_ _5501_/A VGND VGND VPWR VPWR _5501_/X sky130_fd_sc_hd__buf_2
X_6481_ _6481_/A _6481_/B VGND VGND VPWR VPWR _6550_/C sky130_fd_sc_hd__or2_1
X_8220_ _9020_/CLK _8220_/D VGND VGND VPWR VPWR _8220_/Q sky130_fd_sc_hd__dfxtp_1
X_5432_ _5432_/A VGND VGND VPWR VPWR _5432_/X sky130_fd_sc_hd__buf_2
XFILLER_126_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5363_ _8285_/Q _5357_/X _5140_/X _5360_/X VGND VGND VPWR VPWR _8285_/D sky130_fd_sc_hd__a22o_1
X_8151_ _8986_/CLK _8151_/D VGND VGND VPWR VPWR _8151_/Q sky130_fd_sc_hd__dfxtp_1
X_7102_ _8803_/Q _8323_/Q _8931_/Q _8451_/Q _7190_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7102_/X sky130_fd_sc_hd__mux4_1
XFILLER_99_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4314_ _4374_/A VGND VGND VPWR VPWR _4376_/A sky130_fd_sc_hd__inv_2
X_5294_ _8330_/Q _5291_/X _5186_/X _5292_/X VGND VGND VPWR VPWR _8330_/D sky130_fd_sc_hd__a22o_1
XFILLER_114_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8082_ _9044_/CLK _8082_/D VGND VGND VPWR VPWR _8082_/Q sky130_fd_sc_hd__dfxtp_1
X_4245_ _4252_/A VGND VGND VPWR VPWR _4245_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_59_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7033_ _6563_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7033_/X sky130_fd_sc_hd__mux2_2
XFILLER_19_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4176_ _8983_/Q _4171_/X _4026_/X _4172_/X VGND VGND VPWR VPWR _8983_/D sky130_fd_sc_hd__a22o_1
XFILLER_95_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8984_ _9014_/CLK _8984_/D VGND VGND VPWR VPWR _8984_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_43_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7935_ _8732_/Q _8700_/Q _8668_/Q _8636_/Q _7995_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7935_/X sky130_fd_sc_hd__mux4_2
XFILLER_83_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_62_clk clkbuf_4_14_0_clk/X VGND VGND VPWR VPWR _8998_/CLK sky130_fd_sc_hd__clkbuf_16
X_7866_ _7862_/X _7863_/X _7864_/X _7865_/X _5872_/A _5873_/B VGND VGND VPWR VPWR
+ _7866_/X sky130_fd_sc_hd__mux4_1
XPHY_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6817_ _6575_/X _7060_/X _6830_/S VGND VGND VPWR VPWR _6817_/X sky130_fd_sc_hd__mux2_1
XFILLER_23_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7797_ _8597_/Q _8149_/Q _8501_/Q _8789_/Q _7798_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7797_/X sky130_fd_sc_hd__mux4_2
X_6748_ _6414_/Y _6287_/Y _6777_/S VGND VGND VPWR VPWR _9058_/D sky130_fd_sc_hd__mux2_1
XFILLER_136_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6679_ _7012_/X _6103_/Y _6666_/B VGND VGND VPWR VPWR _6679_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_124_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8418_ _8934_/CLK _8418_/D VGND VGND VPWR VPWR _8418_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_124_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8349_ _8863_/CLK _8349_/D VGND VGND VPWR VPWR _8349_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_2_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_53_clk clkbuf_4_13_0_clk/X VGND VGND VPWR VPWR _9034_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_14_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_6_0_clk clkbuf_4_7_0_clk/A VGND VGND VPWR VPWR clkbuf_4_6_0_clk/X sky130_fd_sc_hd__clkbuf_1
XFILLER_41_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4030_ _9046_/Q _4017_/X _4029_/X _4020_/X VGND VGND VPWR VPWR _9046_/D sky130_fd_sc_hd__a22o_1
XFILLER_77_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5981_ _7065_/X _5981_/B VGND VGND VPWR VPWR _6073_/A sky130_fd_sc_hd__nand2_2
XFILLER_65_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_44_clk _9063_/CLK VGND VGND VPWR VPWR _9061_/CLK sky130_fd_sc_hd__clkbuf_16
X_4932_ _6780_/X VGND VGND VPWR VPWR _4932_/X sky130_fd_sc_hd__clkbuf_2
X_7720_ _8977_/Q _8401_/Q _8177_/Q _8753_/Q _7875_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7720_/X sky130_fd_sc_hd__mux4_1
XFILLER_17_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7651_ _7647_/X _7648_/X _7649_/X _7650_/X _7711_/S0 _6097_/A VGND VGND VPWR VPWR
+ _7651_/X sky130_fd_sc_hd__mux4_1
XFILLER_33_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4863_ _4924_/A VGND VGND VPWR VPWR _4888_/A sky130_fd_sc_hd__clkbuf_4
XANTENNA_14 _5229_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6602_ _6602_/A VGND VGND VPWR VPWR _6602_/Y sky130_fd_sc_hd__inv_2
XFILLER_33_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4794_ _4801_/A VGND VGND VPWR VPWR _4794_/X sky130_fd_sc_hd__clkbuf_2
X_7582_ _8810_/Q _8330_/Q _8938_/Q _8458_/Q _7604_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7582_/X sky130_fd_sc_hd__mux4_1
XANTENNA_47 _9075_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_36 _7546_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_25 _6118_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6533_ _6833_/X _6031_/A _6836_/X _6034_/A VGND VGND VPWR VPWR _6533_/X sky130_fd_sc_hd__a22o_1
XFILLER_134_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6464_ _6464_/A _6464_/B VGND VGND VPWR VPWR _6465_/B sky130_fd_sc_hd__or2_1
XFILLER_118_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8203_ _9031_/CLK _8203_/D VGND VGND VPWR VPWR _8203_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_106_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5415_ _8252_/Q _5405_/X _5414_/X _5408_/X VGND VGND VPWR VPWR _8252_/D sky130_fd_sc_hd__a22o_1
X_6395_ _6368_/X _7046_/X VGND VGND VPWR VPWR _6395_/Y sky130_fd_sc_hd__nand2b_1
X_5346_ _5346_/A VGND VGND VPWR VPWR _5346_/X sky130_fd_sc_hd__buf_2
XFILLER_114_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8134_ _9028_/CLK _8134_/D VGND VGND VPWR VPWR _8134_/Q sky130_fd_sc_hd__dfxtp_1
X_8065_ _8929_/CLK _8065_/D VGND VGND VPWR VPWR _8065_/Q sky130_fd_sc_hd__dfxtp_1
X_5277_ _5277_/A VGND VGND VPWR VPWR _5277_/X sky130_fd_sc_hd__buf_2
XFILLER_102_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7016_ _7666_/X _7671_/X _7022_/S VGND VGND VPWR VPWR _7016_/X sky130_fd_sc_hd__mux2_1
X_4228_ _8951_/Q _4223_/X _4026_/X _4224_/X VGND VGND VPWR VPWR _8951_/D sky130_fd_sc_hd__a22o_1
XFILLER_101_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4159_ _6814_/X _4261_/B VGND VGND VPWR VPWR _5627_/B sky130_fd_sc_hd__or2_2
XFILLER_55_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8967_ _9031_/CLK _8967_/D VGND VGND VPWR VPWR _8967_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_83_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7918_ _8283_/Q _8251_/Q _8219_/Q _9019_/Q _7919_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7918_/X sky130_fd_sc_hd__mux4_1
XFILLER_43_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_35_clk clkbuf_4_7_0_clk/X VGND VGND VPWR VPWR _8907_/CLK sky130_fd_sc_hd__clkbuf_16
X_8898_ _8933_/CLK _8898_/D VGND VGND VPWR VPWR _8898_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_102_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7849_ _8119_/Q _8087_/Q _8055_/Q _9047_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7849_/X sky130_fd_sc_hd__mux4_2
XPHY_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_26_clk clkbuf_4_5_0_clk/X VGND VGND VPWR VPWR _8735_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_15_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput12 imData[1] VGND VGND VPWR VPWR _3986_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_128_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput23 imData[2] VGND VGND VPWR VPWR _3980_/A sky130_fd_sc_hd__clkbuf_2
Xinput34 regAddr[1] VGND VGND VPWR VPWR input34/X sky130_fd_sc_hd__buf_2
XFILLER_6_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5200_ _6782_/X VGND VGND VPWR VPWR _5200_/X sky130_fd_sc_hd__clkbuf_2
X_6180_ _6181_/B VGND VGND VPWR VPWR _6180_/Y sky130_fd_sc_hd__inv_2
XFILLER_111_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5131_ _5531_/A _5579_/A VGND VGND VPWR VPWR _5194_/A sky130_fd_sc_hd__or2_4
X_5062_ _8464_/Q _5060_/X _4899_/X _5061_/X VGND VGND VPWR VPWR _8464_/D sky130_fd_sc_hd__a22o_1
X_4013_ _9051_/Q _3998_/X _4012_/X _4003_/X VGND VGND VPWR VPWR _9051_/D sky130_fd_sc_hd__a22o_1
XFILLER_53_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8821_ _8821_/CLK _8821_/D VGND VGND VPWR VPWR _8821_/Q sky130_fd_sc_hd__dfxtp_1
X_8752_ _8816_/CLK _8752_/D VGND VGND VPWR VPWR _8752_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_17_clk clkbuf_4_4_0_clk/X VGND VGND VPWR VPWR _8958_/CLK sky130_fd_sc_hd__clkbuf_16
X_5964_ _7059_/X _5981_/B VGND VGND VPWR VPWR _5965_/A sky130_fd_sc_hd__and2_1
X_7703_ _8432_/Q _8304_/Q _8368_/Q _8560_/Q _7710_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7703_/X sky130_fd_sc_hd__mux4_1
X_8683_ _8873_/CLK _8683_/D VGND VGND VPWR VPWR _8683_/Q sky130_fd_sc_hd__dfxtp_1
X_4915_ _8554_/Q _4910_/X _4914_/X _4912_/X VGND VGND VPWR VPWR _8554_/D sky130_fd_sc_hd__a22o_1
X_5895_ _5797_/A _5894_/X _5797_/A _5894_/X VGND VGND VPWR VPWR _5895_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_139_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4846_ _8585_/Q _4842_/X _4643_/X _4843_/X VGND VGND VPWR VPWR _8585_/D sky130_fd_sc_hd__a22o_1
X_7634_ _8525_/Q _8909_/Q _8845_/Q _8877_/Q _7655_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7634_/X sky130_fd_sc_hd__mux4_1
XFILLER_20_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7565_ _8713_/Q _8681_/Q _8649_/Q _8617_/Q _7604_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7565_/X sky130_fd_sc_hd__mux4_1
X_6516_ _6515_/Y _6033_/A _6836_/X _6664_/B VGND VGND VPWR VPWR _6524_/A sky130_fd_sc_hd__a22o_1
X_4777_ _8632_/Q _4773_/X _4607_/X _4774_/X VGND VGND VPWR VPWR _8632_/D sky130_fd_sc_hd__a22o_1
X_7496_ _7492_/X _7493_/X _7494_/X _7495_/X input16/X _7601_/S1 VGND VGND VPWR VPWR
+ _7496_/X sky130_fd_sc_hd__mux4_2
XFILLER_106_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6447_ _7039_/X VGND VGND VPWR VPWR _6612_/A sky130_fd_sc_hd__inv_2
XFILLER_134_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6378_ _6304_/Y _6309_/B _6262_/X VGND VGND VPWR VPWR _6379_/A sky130_fd_sc_hd__o21ai_1
XFILLER_121_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8117_ _8981_/CLK _8117_/D VGND VGND VPWR VPWR _8117_/Q sky130_fd_sc_hd__dfxtp_1
X_5329_ _8307_/Q _5325_/X _5164_/X _5326_/X VGND VGND VPWR VPWR _8307_/D sky130_fd_sc_hd__a22o_1
XFILLER_57_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8048_ _8975_/CLK _8048_/D VGND VGND VPWR VPWR _8048_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_75_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4700_ _8683_/Q _4698_/X _4638_/X _4699_/X VGND VGND VPWR VPWR _8683_/D sky130_fd_sc_hd__a22o_1
X_5680_ _5694_/A VGND VGND VPWR VPWR _5680_/X sky130_fd_sc_hd__clkbuf_2
X_4631_ _4631_/A VGND VGND VPWR VPWR _4631_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_8_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4562_ _4576_/A VGND VGND VPWR VPWR _4562_/X sky130_fd_sc_hd__clkbuf_2
X_7350_ _8987_/Q _8411_/Q _8187_/Q _8763_/Q _7359_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7350_/X sky130_fd_sc_hd__mux4_1
XFILLER_128_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6301_ _6301_/A VGND VGND VPWR VPWR _6301_/Y sky130_fd_sc_hd__inv_2
X_4493_ _4529_/A VGND VGND VPWR VPWR _4508_/A sky130_fd_sc_hd__buf_4
X_7281_ _7277_/X _7278_/X _7279_/X _7280_/X _7291_/S0 input36/X VGND VGND VPWR VPWR
+ _7281_/X sky130_fd_sc_hd__mux4_1
XFILLER_116_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9020_ _9020_/CLK _9020_/D VGND VGND VPWR VPWR _9020_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_6_clk clkbuf_4_1_0_clk/X VGND VGND VPWR VPWR _9019_/CLK sky130_fd_sc_hd__clkbuf_16
X_6232_ _6232_/A _6232_/B VGND VGND VPWR VPWR _6232_/X sky130_fd_sc_hd__or2_2
XFILLER_103_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6163_ _9082_/Q _6163_/B VGND VGND VPWR VPWR _6164_/A sky130_fd_sc_hd__nand2_1
X_6094_ _5951_/X _6980_/X VGND VGND VPWR VPWR _6094_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_85_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5114_ _8428_/Q _5108_/X _4908_/X _5109_/X VGND VGND VPWR VPWR _8428_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5045_ _8475_/Q _5037_/X _4872_/X _5040_/X VGND VGND VPWR VPWR _8475_/D sky130_fd_sc_hd__a22o_1
XFILLER_26_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8804_ _8868_/CLK _8804_/D VGND VGND VPWR VPWR _8804_/Q sky130_fd_sc_hd__dfxtp_1
X_6996_ _7536_/X _7541_/X _7071_/S VGND VGND VPWR VPWR _6996_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8735_ _8735_/CLK _8735_/D VGND VGND VPWR VPWR _8735_/Q sky130_fd_sc_hd__dfxtp_1
X_5947_ _5947_/A _5947_/B VGND VGND VPWR VPWR _5947_/Y sky130_fd_sc_hd__nor2_1
XFILLER_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8666_ _8954_/CLK _8666_/D VGND VGND VPWR VPWR _8666_/Q sky130_fd_sc_hd__dfxtp_1
X_5878_ _5782_/Y _5785_/A _5886_/A _6513_/B VGND VGND VPWR VPWR _5878_/X sky130_fd_sc_hd__o22a_1
X_7617_ _8588_/Q _8140_/Q _8492_/Q _8780_/Q _7659_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7617_/X sky130_fd_sc_hd__mux4_2
XFILLER_21_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4829_ _4829_/A VGND VGND VPWR VPWR _4829_/X sky130_fd_sc_hd__buf_2
X_8597_ _9013_/CLK _8597_/D VGND VGND VPWR VPWR _8597_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_135_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7548_ _8264_/Q _8232_/Q _8200_/Q _9000_/Q _7550_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7548_/X sky130_fd_sc_hd__mux4_1
XFILLER_5_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7479_ _8101_/Q _8069_/Q _8037_/Q _9029_/Q _7480_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7479_/X sky130_fd_sc_hd__mux4_1
XFILLER_134_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6850_ _6849_/X _5881_/X _6948_/S VGND VGND VPWR VPWR _6850_/X sky130_fd_sc_hd__mux2_1
XFILLER_35_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6781_ _5928_/Y _5940_/Y _6809_/S VGND VGND VPWR VPWR _6781_/X sky130_fd_sc_hd__mux2_4
X_5801_ _6984_/X _6040_/B VGND VGND VPWR VPWR _5802_/A sky130_fd_sc_hd__nand2_2
XFILLER_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8520_ _8545_/CLK _8520_/D VGND VGND VPWR VPWR _8520_/Q sky130_fd_sc_hd__dfxtp_1
X_3993_ _5035_/A VGND VGND VPWR VPWR _4537_/A sky130_fd_sc_hd__buf_1
X_5732_ _8060_/Q _5725_/X _4597_/A _5728_/X VGND VGND VPWR VPWR _8060_/D sky130_fd_sc_hd__a22o_1
XFILLER_22_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5663_ _8105_/Q _5659_/X _5460_/X _5660_/X VGND VGND VPWR VPWR _8105_/D sky130_fd_sc_hd__a22o_1
X_8451_ _8932_/CLK _8451_/D VGND VGND VPWR VPWR _8451_/Q sky130_fd_sc_hd__dfxtp_1
X_8382_ _8734_/CLK _8382_/D VGND VGND VPWR VPWR _8382_/Q sky130_fd_sc_hd__dfxtp_1
X_7402_ _8801_/Q _8321_/Q _8929_/Q _8449_/Q _7550_/S0 _7604_/S1 VGND VGND VPWR VPWR
+ _7402_/X sky130_fd_sc_hd__mux4_2
X_5594_ _8152_/Q _5590_/X _5424_/X _5591_/X VGND VGND VPWR VPWR _8152_/D sky130_fd_sc_hd__a22o_1
X_4614_ _4614_/A VGND VGND VPWR VPWR _4614_/X sky130_fd_sc_hd__buf_2
XFILLER_116_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4545_ _8765_/Q _4539_/X _4320_/X _4542_/X VGND VGND VPWR VPWR _8765_/D sky130_fd_sc_hd__a22o_1
X_7333_ _8442_/Q _8314_/Q _8378_/Q _8570_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7333_/X sky130_fd_sc_hd__mux4_2
XFILLER_128_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4476_ _8809_/Q _4472_/X _4368_/X _4473_/X VGND VGND VPWR VPWR _8809_/D sky130_fd_sc_hd__a22o_1
X_9003_ _9035_/CLK _9003_/D VGND VGND VPWR VPWR _9003_/Q sky130_fd_sc_hd__dfxtp_1
X_7264_ _8531_/Q _8915_/Q _8851_/Q _8883_/Q _7288_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7264_/X sky130_fd_sc_hd__mux4_2
X_7195_ _8716_/Q _8684_/Q _8652_/Q _8620_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7195_/X sky130_fd_sc_hd__mux4_1
X_6215_ _9078_/Q _6211_/A _6156_/A VGND VGND VPWR VPWR _6217_/B sky130_fd_sc_hd__o21ai_1
XFILLER_85_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6146_ _6223_/A _6234_/A _6146_/C _6234_/B VGND VGND VPWR VPWR _6225_/A sky130_fd_sc_hd__nor4_2
XFILLER_57_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater251 _7480_/S0 VGND VGND VPWR VPWR _7579_/S0 sky130_fd_sc_hd__buf_6
Xrepeater262 _7067_/S VGND VGND VPWR VPWR _7022_/S sky130_fd_sc_hd__clkbuf_8
Xrepeater240 _5771_/A VGND VGND VPWR VPWR _8025_/S0 sky130_fd_sc_hd__buf_6
X_6077_ _7066_/X _6073_/Y _5982_/Y _6076_/X VGND VGND VPWR VPWR _6077_/X sky130_fd_sc_hd__o22a_1
X_5028_ _8486_/Q _5026_/X _4923_/X _5027_/X VGND VGND VPWR VPWR _8486_/D sky130_fd_sc_hd__a22o_1
Xrepeater273 _8011_/S0 VGND VGND VPWR VPWR _6098_/A sky130_fd_sc_hd__buf_6
XFILLER_73_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6979_ _6094_/Y _6288_/A _7069_/S VGND VGND VPWR VPWR _6979_/X sky130_fd_sc_hd__mux2_4
XFILLER_80_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8718_ _8877_/CLK _8718_/D VGND VGND VPWR VPWR _8718_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8649_ _8873_/CLK _8649_/D VGND VGND VPWR VPWR _8649_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_110_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4330_ _4605_/A VGND VGND VPWR VPWR _4330_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_125_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4261_ _4261_/A _4261_/B VGND VGND VPWR VPWR _5675_/B sky130_fd_sc_hd__or2_2
XFILLER_4_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6000_ _7039_/X _5996_/X _7036_/X _5999_/X VGND VGND VPWR VPWR _6025_/A sky130_fd_sc_hd__a22o_1
X_4192_ _4199_/A VGND VGND VPWR VPWR _4192_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_95_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7951_ _7947_/X _7948_/X _7949_/X _7950_/X _8011_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _7951_/X sky130_fd_sc_hd__mux4_1
XFILLER_55_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6902_ _6905_/X _6903_/X _6949_/S VGND VGND VPWR VPWR _6902_/X sky130_fd_sc_hd__mux2_2
X_7882_ _8825_/Q _8345_/Q _8953_/Q _8473_/Q _7907_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7882_/X sky130_fd_sc_hd__mux4_1
XFILLER_35_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6833_ _6667_/Y _7018_/X _6943_/S VGND VGND VPWR VPWR _6833_/X sky130_fd_sc_hd__mux2_1
XFILLER_51_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3976_ _5955_/A _3976_/B VGND VGND VPWR VPWR _3982_/C sky130_fd_sc_hd__or2_1
XFILLER_11_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6764_ _6371_/Y _6198_/Y _6777_/S VGND VGND VPWR VPWR _9074_/D sky130_fd_sc_hd__mux2_1
X_5715_ _5715_/A VGND VGND VPWR VPWR _5715_/X sky130_fd_sc_hd__clkbuf_2
X_6695_ _6694_/X _9062_/Q _6735_/S VGND VGND VPWR VPWR _6695_/X sky130_fd_sc_hd__mux2_1
X_8503_ _8922_/CLK _8503_/D VGND VGND VPWR VPWR _8503_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_108_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8434_ _9019_/CLK _8434_/D VGND VGND VPWR VPWR _8434_/Q sky130_fd_sc_hd__dfxtp_1
X_5646_ _5646_/A VGND VGND VPWR VPWR _5646_/X sky130_fd_sc_hd__clkbuf_2
X_5577_ _8161_/Q _5549_/A _5478_/X _5550_/A VGND VGND VPWR VPWR _8161_/D sky130_fd_sc_hd__a22o_1
X_8365_ _8941_/CLK _8365_/D VGND VGND VPWR VPWR _8365_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_132_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8296_ _8669_/CLK _8296_/D VGND VGND VPWR VPWR _8296_/Q sky130_fd_sc_hd__dfxtp_1
X_4528_ _4528_/A VGND VGND VPWR VPWR _4528_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_2_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7316_ _7312_/X _7313_/X _7314_/X _7315_/X _7341_/S0 _7336_/S1 VGND VGND VPWR VPWR
+ _7316_/X sky130_fd_sc_hd__mux4_1
XFILLER_104_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4459_ _4459_/A VGND VGND VPWR VPWR _4459_/X sky130_fd_sc_hd__clkbuf_2
X_7247_ _8593_/Q _8145_/Q _8497_/Q _8785_/Q _7280_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7247_/X sky130_fd_sc_hd__mux4_1
XFILLER_120_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7178_ _8266_/Q _8234_/Q _8202_/Q _9002_/Q _7190_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7178_/X sky130_fd_sc_hd__mux4_1
XFILLER_98_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6129_ _6129_/A _6129_/B VGND VGND VPWR VPWR _6146_/C sky130_fd_sc_hd__or2_1
XFILLER_85_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5500_ _8214_/Q _5494_/X _5428_/X _5495_/X VGND VGND VPWR VPWR _8214_/D sky130_fd_sc_hd__a22o_1
X_6480_ _6820_/X _5974_/Y _6477_/Y _5974_/A VGND VGND VPWR VPWR _6481_/B sky130_fd_sc_hd__a22o_1
X_5431_ _6799_/X VGND VGND VPWR VPWR _5431_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_114_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5362_ _8286_/Q _5357_/X _5138_/X _5360_/X VGND VGND VPWR VPWR _8286_/D sky130_fd_sc_hd__a22o_1
X_8150_ _8790_/CLK _8150_/D VGND VGND VPWR VPWR _8150_/Q sky130_fd_sc_hd__dfxtp_1
X_4313_ _4338_/A VGND VGND VPWR VPWR _4313_/X sky130_fd_sc_hd__clkbuf_2
X_7101_ _7097_/X _7098_/X _7099_/X _7100_/X input35/X _7191_/S1 VGND VGND VPWR VPWR
+ _7101_/X sky130_fd_sc_hd__mux4_1
XFILLER_5_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8081_ _8981_/CLK _8081_/D VGND VGND VPWR VPWR _8081_/Q sky130_fd_sc_hd__dfxtp_1
X_5293_ _8331_/Q _5291_/X _5183_/X _5292_/X VGND VGND VPWR VPWR _8331_/D sky130_fd_sc_hd__a22o_1
X_7032_ _7776_/X _7781_/X _7059_/S VGND VGND VPWR VPWR _7032_/X sky130_fd_sc_hd__mux2_2
X_4244_ _4251_/A VGND VGND VPWR VPWR _4244_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_113_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4175_ _8984_/Q _4171_/X _4023_/X _4172_/X VGND VGND VPWR VPWR _8984_/D sky130_fd_sc_hd__a22o_1
XFILLER_55_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8983_ _9049_/CLK _8983_/D VGND VGND VPWR VPWR _8983_/Q sky130_fd_sc_hd__dfxtp_1
X_7934_ _8540_/Q _8924_/Q _8860_/Q _8892_/Q _7995_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7934_/X sky130_fd_sc_hd__mux4_2
XFILLER_83_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_2107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7865_ _8728_/Q _8696_/Q _8664_/Q _8632_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7865_/X sky130_fd_sc_hd__mux4_2
XPHY_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6816_ _6568_/Y _7063_/X _6830_/S VGND VGND VPWR VPWR _6816_/X sky130_fd_sc_hd__mux2_1
X_7796_ _7792_/X _7793_/X _7794_/X _7795_/X _8031_/S0 _8031_/S1 VGND VGND VPWR VPWR
+ _7796_/X sky130_fd_sc_hd__mux4_2
XPHY_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6747_ _6412_/X _6290_/X _6777_/S VGND VGND VPWR VPWR _9057_/D sky130_fd_sc_hd__mux2_1
XPHY_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6678_ _6841_/X _5946_/A _6100_/X _6677_/Y VGND VGND VPWR VPWR _6678_/Y sky130_fd_sc_hd__o22ai_1
X_8417_ _8545_/CLK _8417_/D VGND VGND VPWR VPWR _8417_/Q sky130_fd_sc_hd__dfxtp_1
X_5629_ _5645_/A VGND VGND VPWR VPWR _5629_/X sky130_fd_sc_hd__clkbuf_2
X_8348_ _8731_/CLK _8348_/D VGND VGND VPWR VPWR _8348_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_2_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8279_ _8951_/CLK _8279_/D VGND VGND VPWR VPWR _8279_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_59_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5980_ _7066_/X VGND VGND VPWR VPWR _5982_/A sky130_fd_sc_hd__inv_2
XFILLER_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4931_ _8547_/Q _4922_/X _4930_/X _4924_/X VGND VGND VPWR VPWR _8547_/D sky130_fd_sc_hd__a22o_1
XFILLER_64_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4862_ _4922_/A VGND VGND VPWR VPWR _4924_/A sky130_fd_sc_hd__clkinv_4
X_7650_ _8973_/Q _8397_/Q _8173_/Q _8749_/Q _7665_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7650_/X sky130_fd_sc_hd__mux4_1
X_6601_ _6488_/Y _5986_/A _6550_/D _6550_/B VGND VGND VPWR VPWR _6602_/A sky130_fd_sc_hd__o22a_1
XANTENNA_37 _7176_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7581_ _7577_/X _7578_/X _7579_/X _7580_/X _5771_/C _7601_/S1 VGND VGND VPWR VPWR
+ _7581_/X sky130_fd_sc_hd__mux4_1
XANTENNA_26 _6301_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4793_ _8620_/Q _4787_/X _4635_/X _4788_/X VGND VGND VPWR VPWR _8620_/D sky130_fd_sc_hd__a22o_1
XANTENNA_48 _9076_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_15 _5430_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6532_ _6836_/X _6034_/A _6528_/Y _6531_/Y VGND VGND VPWR VPWR _6532_/X sky130_fd_sc_hd__o22a_1
XFILLER_9_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6463_ _6463_/A _6463_/B VGND VGND VPWR VPWR _6464_/B sky130_fd_sc_hd__or2_1
XFILLER_9_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8202_ _8778_/CLK _8202_/D VGND VGND VPWR VPWR _8202_/Q sky130_fd_sc_hd__dfxtp_1
Xoutput100 _6697_/X VGND VGND VPWR VPWR regData[7] sky130_fd_sc_hd__clkbuf_2
X_5414_ _6806_/X VGND VGND VPWR VPWR _5414_/X sky130_fd_sc_hd__clkbuf_2
X_8133_ _8998_/CLK _8133_/D VGND VGND VPWR VPWR _8133_/Q sky130_fd_sc_hd__dfxtp_1
X_6394_ _6308_/A _6393_/X _6308_/A _6393_/X VGND VGND VPWR VPWR _6394_/Y sky130_fd_sc_hd__a2bb2oi_1
X_5345_ _8295_/Q _5339_/X _5192_/X _5340_/X VGND VGND VPWR VPWR _8295_/D sky130_fd_sc_hd__a22o_1
XFILLER_102_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8064_ _9024_/CLK _8064_/D VGND VGND VPWR VPWR _8064_/Q sky130_fd_sc_hd__dfxtp_1
X_5276_ _8342_/Q _5270_/X _5156_/X _5271_/X VGND VGND VPWR VPWR _8342_/D sky130_fd_sc_hd__a22o_1
XFILLER_75_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7015_ _6645_/Y _6232_/A _7069_/S VGND VGND VPWR VPWR _7015_/X sky130_fd_sc_hd__mux2_4
X_4227_ _8952_/Q _4223_/X _4023_/X _4224_/X VGND VGND VPWR VPWR _8952_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4158_ _4210_/C _6813_/X VGND VGND VPWR VPWR _4261_/B sky130_fd_sc_hd__or2b_1
X_8966_ _8966_/CLK _8966_/D VGND VGND VPWR VPWR _8966_/Q sky130_fd_sc_hd__dfxtp_1
X_4089_ _9029_/Q _4085_/X _4087_/X _4088_/X VGND VGND VPWR VPWR _9029_/D sky130_fd_sc_hd__a22o_1
XFILLER_55_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7917_ _8603_/Q _8155_/Q _8507_/Q _8795_/Q _7919_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7917_/X sky130_fd_sc_hd__mux4_1
X_8897_ _8926_/CLK _8897_/D VGND VGND VPWR VPWR _8897_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_70_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7848_ _8279_/Q _8247_/Q _8215_/Q _9015_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7848_/X sky130_fd_sc_hd__mux4_2
XPHY_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7779_ _8116_/Q _8084_/Q _8052_/Q _9044_/Q _7875_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7779_/X sky130_fd_sc_hd__mux4_1
XPHY_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput13 imData[20] VGND VGND VPWR VPWR _7049_/S sky130_fd_sc_hd__clkbuf_2
Xinput24 imData[30] VGND VGND VPWR VPWR _3971_/B sky130_fd_sc_hd__clkbuf_1
Xinput35 regAddr[2] VGND VGND VPWR VPWR input35/X sky130_fd_sc_hd__buf_6
XPHY_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5130_ _8416_/Q _5101_/A _4936_/X _5102_/A VGND VGND VPWR VPWR _8416_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5061_ _5075_/A VGND VGND VPWR VPWR _5061_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_57_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4012_ _4599_/A VGND VGND VPWR VPWR _4012_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_38_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8820_ _8947_/CLK _8820_/D VGND VGND VPWR VPWR _8820_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_92_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5963_ _5963_/A VGND VGND VPWR VPWR _5963_/Y sky130_fd_sc_hd__inv_2
XFILLER_53_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8751_ _8816_/CLK _8751_/D VGND VGND VPWR VPWR _8751_/Q sky130_fd_sc_hd__dfxtp_1
X_4914_ _6788_/X VGND VGND VPWR VPWR _4914_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_53_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7702_ _8816_/Q _8336_/Q _8944_/Q _8464_/Q _7710_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7702_/X sky130_fd_sc_hd__mux4_1
X_8682_ _8873_/CLK _8682_/D VGND VGND VPWR VPWR _8682_/Q sky130_fd_sc_hd__dfxtp_1
X_5894_ _5790_/Y _5795_/A _5797_/B _5893_/X VGND VGND VPWR VPWR _5894_/X sky130_fd_sc_hd__o22a_1
XFILLER_61_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4845_ _8586_/Q _4842_/X _4641_/X _4843_/X VGND VGND VPWR VPWR _8586_/D sky130_fd_sc_hd__a22o_1
X_7633_ _8429_/Q _8301_/Q _8365_/Q _8557_/Q _7659_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7633_/X sky130_fd_sc_hd__mux4_1
XFILLER_21_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7564_ _8521_/Q _8905_/Q _8841_/Q _8873_/Q _7604_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7564_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4776_ _8633_/Q _4773_/X _4605_/X _4774_/X VGND VGND VPWR VPWR _8633_/D sky130_fd_sc_hd__a22o_1
XFILLER_20_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6515_ _6836_/X VGND VGND VPWR VPWR _6515_/Y sky130_fd_sc_hd__inv_2
X_7495_ _8710_/Q _8678_/Q _8646_/Q _8614_/Q _7579_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7495_/X sky130_fd_sc_hd__mux4_2
XFILLER_119_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6446_ _7042_/X VGND VGND VPWR VPWR _6459_/A sky130_fd_sc_hd__inv_2
X_6377_ _6368_/X _7052_/X VGND VGND VPWR VPWR _6377_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_87_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8116_ _9044_/CLK _8116_/D VGND VGND VPWR VPWR _8116_/Q sky130_fd_sc_hd__dfxtp_1
X_5328_ _8308_/Q _5325_/X _5162_/X _5326_/X VGND VGND VPWR VPWR _8308_/D sky130_fd_sc_hd__a22o_1
XFILLER_130_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8047_ _8975_/CLK _8047_/D VGND VGND VPWR VPWR _8047_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_5_0_clk clkbuf_4_5_0_clk/A VGND VGND VPWR VPWR clkbuf_4_5_0_clk/X sky130_fd_sc_hd__clkbuf_1
X_5259_ _5259_/A _5675_/B VGND VGND VPWR VPWR _5298_/A sky130_fd_sc_hd__or2_4
XFILLER_75_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8949_ _9013_/CLK _8949_/D VGND VGND VPWR VPWR _8949_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4630_ _8719_/Q _4625_/X _4629_/X _4627_/X VGND VGND VPWR VPWR _8719_/D sky130_fd_sc_hd__a22o_1
XPHY_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6300_ _5931_/Y _6271_/A _6268_/Y _5917_/Y _6267_/A VGND VGND VPWR VPWR _6301_/A
+ sky130_fd_sc_hd__o32a_1
X_4561_ _8753_/Q _4555_/X _4348_/X _4556_/X VGND VGND VPWR VPWR _8753_/D sky130_fd_sc_hd__a22o_1
X_4492_ _4528_/A VGND VGND VPWR VPWR _4529_/A sky130_fd_sc_hd__inv_2
X_7280_ _8980_/Q _8404_/Q _8180_/Q _8756_/Q _7280_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7280_/X sky130_fd_sc_hd__mux4_1
XFILLER_104_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6231_ input6/X VGND VGND VPWR VPWR _6232_/A sky130_fd_sc_hd__inv_2
X_6162_ _6162_/A VGND VGND VPWR VPWR _6163_/B sky130_fd_sc_hd__inv_2
X_5113_ _8429_/Q _5108_/X _4906_/X _5109_/X VGND VGND VPWR VPWR _8429_/D sky130_fd_sc_hd__a22o_1
X_6093_ _5951_/X _6977_/X VGND VGND VPWR VPWR _6093_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_58_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5044_ _8476_/Q _5037_/X _4870_/X _5040_/X VGND VGND VPWR VPWR _8476_/D sky130_fd_sc_hd__a22o_1
X_8803_ _8934_/CLK _8803_/D VGND VGND VPWR VPWR _8803_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_93_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6995_ _7526_/X _7531_/X _7067_/S VGND VGND VPWR VPWR _6995_/X sky130_fd_sc_hd__mux2_1
X_8734_ _8734_/CLK _8734_/D VGND VGND VPWR VPWR _8734_/Q sky130_fd_sc_hd__dfxtp_1
X_5946_ _5946_/A VGND VGND VPWR VPWR _5946_/X sky130_fd_sc_hd__clkbuf_2
X_5877_ _5882_/A _5866_/B _5867_/B VGND VGND VPWR VPWR _5877_/X sky130_fd_sc_hd__a21bo_1
X_8665_ _8665_/CLK _8665_/D VGND VGND VPWR VPWR _8665_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_33_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7616_ _7612_/X _7613_/X _7614_/X _7615_/X _7701_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7616_/X sky130_fd_sc_hd__mux4_2
X_4828_ _4828_/A VGND VGND VPWR VPWR _4828_/X sky130_fd_sc_hd__buf_2
X_8596_ _9044_/CLK _8596_/D VGND VGND VPWR VPWR _8596_/Q sky130_fd_sc_hd__dfxtp_1
X_4759_ _8642_/Q _4753_/X _4659_/X _4754_/X VGND VGND VPWR VPWR _8642_/D sky130_fd_sc_hd__a22o_1
XFILLER_119_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7547_ _8584_/Q _8136_/Q _8488_/Q _8776_/Q _7550_/S0 _7604_/S1 VGND VGND VPWR VPWR
+ _7547_/X sky130_fd_sc_hd__mux4_1
XFILLER_5_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7478_ _8261_/Q _8229_/Q _8197_/Q _8997_/Q _7480_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7478_/X sky130_fd_sc_hd__mux4_1
X_6429_ _3982_/C _6428_/X _3982_/C _6428_/X VGND VGND VPWR VPWR _6430_/B sky130_fd_sc_hd__o2bb2a_1
XFILLER_122_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9079_ _9080_/CLK _9079_/D repeater147/X VGND VGND VPWR VPWR _9079_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_124_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5800_ _5800_/A VGND VGND VPWR VPWR _5914_/B sky130_fd_sc_hd__buf_1
X_6780_ _5945_/Y _5950_/X _6809_/S VGND VGND VPWR VPWR _6780_/X sky130_fd_sc_hd__mux2_4
X_3992_ _6813_/X _4261_/A _4210_/C VGND VGND VPWR VPWR _5035_/A sky130_fd_sc_hd__or3_4
X_5731_ _8061_/Q _5725_/X _4595_/A _5728_/X VGND VGND VPWR VPWR _8061_/D sky130_fd_sc_hd__a22o_1
XFILLER_50_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5662_ _8106_/Q _5659_/X _5458_/X _5660_/X VGND VGND VPWR VPWR _8106_/D sky130_fd_sc_hd__a22o_1
X_8450_ _8934_/CLK _8450_/D VGND VGND VPWR VPWR _8450_/Q sky130_fd_sc_hd__dfxtp_1
X_8381_ _8863_/CLK _8381_/D VGND VGND VPWR VPWR _8381_/Q sky130_fd_sc_hd__dfxtp_1
X_7401_ _7397_/X _7398_/X _7399_/X _7400_/X _5771_/C _5771_/B VGND VGND VPWR VPWR
+ _7401_/X sky130_fd_sc_hd__mux4_1
X_4613_ _4613_/A VGND VGND VPWR VPWR _4613_/X sky130_fd_sc_hd__clkbuf_2
X_5593_ _8153_/Q _5590_/X _5422_/X _5591_/X VGND VGND VPWR VPWR _8153_/D sky130_fd_sc_hd__a22o_1
X_4544_ _8766_/Q _4539_/X _4318_/X _4542_/X VGND VGND VPWR VPWR _8766_/D sky130_fd_sc_hd__a22o_1
X_7332_ _8826_/Q _8346_/Q _8954_/Q _8474_/Q _7334_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7332_/X sky130_fd_sc_hd__mux4_1
X_7263_ _8435_/Q _8307_/Q _8371_/Q _8563_/Q _7288_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7263_/X sky130_fd_sc_hd__mux4_1
X_4475_ _8810_/Q _4472_/X _4366_/X _4473_/X VGND VGND VPWR VPWR _8810_/D sky130_fd_sc_hd__a22o_1
X_9002_ _9034_/CLK _9002_/D VGND VGND VPWR VPWR _9002_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_104_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6214_ _6214_/A _6214_/B VGND VGND VPWR VPWR _6222_/A sky130_fd_sc_hd__or2_1
XFILLER_131_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7194_ _8524_/Q _8908_/Q _8844_/Q _8876_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7194_/X sky130_fd_sc_hd__mux4_1
X_6145_ _6245_/A _6255_/A _6145_/C _6255_/B VGND VGND VPWR VPWR _6234_/B sky130_fd_sc_hd__or4_4
X_6076_ _6437_/A _5963_/Y _5993_/A _6075_/X VGND VGND VPWR VPWR _6076_/X sky130_fd_sc_hd__o22a_1
Xrepeater230 _7595_/S1 VGND VGND VPWR VPWR _5772_/B sky130_fd_sc_hd__buf_8
XFILLER_100_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5027_ _5027_/A VGND VGND VPWR VPWR _5027_/X sky130_fd_sc_hd__clkbuf_2
Xrepeater252 _7655_/S0 VGND VGND VPWR VPWR _7480_/S0 sky130_fd_sc_hd__buf_8
Xrepeater241 _8000_/S0 VGND VGND VPWR VPWR _7919_/S0 sky130_fd_sc_hd__buf_6
Xrepeater274 _8006_/S0 VGND VGND VPWR VPWR _8011_/S0 sky130_fd_sc_hd__buf_6
Xrepeater263 _7070_/S VGND VGND VPWR VPWR _7067_/S sky130_fd_sc_hd__buf_8
XFILLER_54_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6978_ _7416_/X _7421_/X _7020_/S VGND VGND VPWR VPWR _6978_/X sky130_fd_sc_hd__mux2_2
X_8717_ _8876_/CLK _8717_/D VGND VGND VPWR VPWR _8717_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_41_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5929_ _6985_/X _5861_/B _5862_/B VGND VGND VPWR VPWR _5929_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_22_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8648_ _8873_/CLK _8648_/D VGND VGND VPWR VPWR _8648_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8579_ _8966_/CLK _8579_/D VGND VGND VPWR VPWR _8579_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_119_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_125_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4260_ _4858_/A _6811_/X _4488_/C VGND VGND VPWR VPWR _4938_/B sky130_fd_sc_hd__or3_4
X_4191_ _8972_/Q _4185_/X _4063_/X _4186_/X VGND VGND VPWR VPWR _8972_/D sky130_fd_sc_hd__a22o_1
XFILLER_79_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7950_ _8988_/Q _8412_/Q _8188_/Q _8764_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _7950_/X sky130_fd_sc_hd__mux4_1
XFILLER_36_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6901_ _6900_/X _6902_/X _6948_/S VGND VGND VPWR VPWR _6901_/X sky130_fd_sc_hd__mux2_1
XFILLER_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7881_ _7877_/X _7878_/X _7879_/X _7880_/X _7901_/S0 _8031_/S1 VGND VGND VPWR VPWR
+ _7881_/X sky130_fd_sc_hd__mux4_2
X_6832_ _6831_/X _6560_/X _6948_/S VGND VGND VPWR VPWR _6832_/X sky130_fd_sc_hd__mux2_1
XFILLER_35_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3975_ _3986_/A VGND VGND VPWR VPWR _3988_/B sky130_fd_sc_hd__inv_2
X_6763_ _6376_/X _6194_/Y _6777_/S VGND VGND VPWR VPWR _9073_/D sky130_fd_sc_hd__mux2_1
X_5714_ _5714_/A VGND VGND VPWR VPWR _5714_/X sky130_fd_sc_hd__clkbuf_2
X_6694_ _7136_/X _7141_/X _6704_/S VGND VGND VPWR VPWR _6694_/X sky130_fd_sc_hd__mux2_4
X_8502_ _8950_/CLK _8502_/D VGND VGND VPWR VPWR _8502_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_136_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5645_ _5645_/A VGND VGND VPWR VPWR _5645_/X sky130_fd_sc_hd__clkbuf_2
X_8433_ _8947_/CLK _8433_/D VGND VGND VPWR VPWR _8433_/Q sky130_fd_sc_hd__dfxtp_1
X_5576_ _8162_/Q _5570_/X _5476_/X _5571_/X VGND VGND VPWR VPWR _8162_/D sky130_fd_sc_hd__a22o_1
X_8364_ _8780_/CLK _8364_/D VGND VGND VPWR VPWR _8364_/Q sky130_fd_sc_hd__dfxtp_1
X_4527_ _8775_/Q _4521_/X _4372_/X _4522_/X VGND VGND VPWR VPWR _8775_/D sky130_fd_sc_hd__a22o_1
X_8295_ _8456_/CLK _8295_/D VGND VGND VPWR VPWR _8295_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_105_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7315_ _8728_/Q _8696_/Q _8664_/Q _8632_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7315_/X sky130_fd_sc_hd__mux4_2
XFILLER_131_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7246_ _7242_/X _7243_/X _7244_/X _7245_/X _7291_/S0 input36/X VGND VGND VPWR VPWR
+ _7246_/X sky130_fd_sc_hd__mux4_2
X_4458_ _4458_/A VGND VGND VPWR VPWR _4458_/X sky130_fd_sc_hd__clkbuf_2
X_7177_ _8586_/Q _8138_/Q _8490_/Q _8778_/Q _7190_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7177_/X sky130_fd_sc_hd__mux4_1
XFILLER_132_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4389_ _8864_/Q _4338_/A _4388_/X _4340_/A VGND VGND VPWR VPWR _8864_/D sky130_fd_sc_hd__a22o_1
X_6128_ _9070_/Q VGND VGND VPWR VPWR _6129_/B sky130_fd_sc_hd__inv_2
XFILLER_85_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6059_ _6059_/A _6059_/B _6059_/C _6046_/X VGND VGND VPWR VPWR _6085_/A sky130_fd_sc_hd__or4b_4
XFILLER_65_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5430_ _5430_/A VGND VGND VPWR VPWR _5430_/X sky130_fd_sc_hd__buf_2
XFILLER_65_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5361_ _8287_/Q _5357_/X _5213_/X _5360_/X VGND VGND VPWR VPWR _8287_/D sky130_fd_sc_hd__a22o_1
X_5292_ _5299_/A VGND VGND VPWR VPWR _5292_/X sky130_fd_sc_hd__clkbuf_2
X_7100_ _8962_/Q _8386_/Q _8162_/Q _8738_/Q _7130_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7100_/X sky130_fd_sc_hd__mux4_1
X_4312_ _4374_/A VGND VGND VPWR VPWR _4338_/A sky130_fd_sc_hd__clkbuf_4
X_8080_ _9087_/CLK _8080_/D VGND VGND VPWR VPWR _8080_/Q sky130_fd_sc_hd__dfxtp_1
X_4243_ _8940_/Q _4237_/X _4063_/X _4238_/X VGND VGND VPWR VPWR _8940_/D sky130_fd_sc_hd__a22o_1
X_7031_ _7766_/X _7771_/X _7070_/S VGND VGND VPWR VPWR _7031_/X sky130_fd_sc_hd__mux2_2
XFILLER_99_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4174_ _8985_/Q _4171_/X _4019_/X _4172_/X VGND VGND VPWR VPWR _8985_/D sky130_fd_sc_hd__a22o_1
XFILLER_82_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8982_ _9014_/CLK _8982_/D VGND VGND VPWR VPWR _8982_/Q sky130_fd_sc_hd__dfxtp_1
X_7933_ _8444_/Q _8316_/Q _8380_/Q _8572_/Q _7995_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7933_/X sky130_fd_sc_hd__mux4_1
XFILLER_67_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_2108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7864_ _8536_/Q _8920_/Q _8856_/Q _8888_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7864_/X sky130_fd_sc_hd__mux4_1
XFILLER_35_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6815_ _6468_/X _7066_/X _6830_/S VGND VGND VPWR VPWR _6815_/X sky130_fd_sc_hd__mux2_1
X_7795_ _8725_/Q _8693_/Q _8661_/Q _8629_/Q _8030_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _7795_/X sky130_fd_sc_hd__mux4_2
XPHY_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6746_ _6431_/Y _6143_/B _6777_/S VGND VGND VPWR VPWR _9056_/D sky130_fd_sc_hd__mux2_1
XPHY_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6677_ _6677_/A _6677_/B VGND VGND VPWR VPWR _6677_/Y sky130_fd_sc_hd__nor2_1
XFILLER_136_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5628_ _5666_/A VGND VGND VPWR VPWR _5645_/A sky130_fd_sc_hd__buf_4
X_8416_ _9054_/CLK _8416_/D VGND VGND VPWR VPWR _8416_/Q sky130_fd_sc_hd__dfxtp_1
X_8347_ _8956_/CLK _8347_/D VGND VGND VPWR VPWR _8347_/Q sky130_fd_sc_hd__dfxtp_1
X_5559_ _8175_/Q _5556_/X _5446_/X _5557_/X VGND VGND VPWR VPWR _8175_/D sky130_fd_sc_hd__a22o_1
XFILLER_104_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8278_ _8952_/CLK _8278_/D VGND VGND VPWR VPWR _8278_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_132_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7229_ _8111_/Q _8079_/Q _8047_/Q _9039_/Q _7229_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7229_/X sky130_fd_sc_hd__mux4_1
XFILLER_116_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4930_ _6781_/X VGND VGND VPWR VPWR _4930_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_52_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4861_ _4886_/A VGND VGND VPWR VPWR _4861_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_17_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6600_ _6461_/A _6461_/B _6462_/B VGND VGND VPWR VPWR _6600_/X sky130_fd_sc_hd__a21bo_1
XFILLER_20_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7580_ _8970_/Q _8394_/Q _8170_/Q _8746_/Q _7600_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7580_/X sky130_fd_sc_hd__mux4_1
X_4792_ _8621_/Q _4787_/X _4633_/X _4788_/X VGND VGND VPWR VPWR _8621_/D sky130_fd_sc_hd__a22o_1
XFILLER_60_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_38 _7306_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_16 _5550_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_27 _6620_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_49 _9081_/Q VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6531_ _6531_/A VGND VGND VPWR VPWR _6531_/Y sky130_fd_sc_hd__inv_2
X_6462_ _6462_/A _6462_/B VGND VGND VPWR VPWR _6463_/B sky130_fd_sc_hd__or2_1
X_8201_ _8778_/CLK _8201_/D VGND VGND VPWR VPWR _8201_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_118_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5413_ _8253_/Q _5405_/X _5412_/X _5408_/X VGND VGND VPWR VPWR _8253_/D sky130_fd_sc_hd__a22o_1
X_6393_ _6308_/B _6391_/X _6251_/X VGND VGND VPWR VPWR _6393_/X sky130_fd_sc_hd__o21a_1
Xoutput101 _6699_/X VGND VGND VPWR VPWR regData[8] sky130_fd_sc_hd__clkbuf_2
X_5344_ _8296_/Q _5339_/X _5190_/X _5340_/X VGND VGND VPWR VPWR _8296_/D sky130_fd_sc_hd__a22o_1
X_8132_ _9027_/CLK _8132_/D VGND VGND VPWR VPWR _8132_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_0_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8063_ _9051_/CLK _8063_/D VGND VGND VPWR VPWR _8063_/Q sky130_fd_sc_hd__dfxtp_1
X_5275_ _8343_/Q _5270_/X _5154_/X _5271_/X VGND VGND VPWR VPWR _8343_/D sky130_fd_sc_hd__a22o_1
X_7014_ _7656_/X _7661_/X _7020_/S VGND VGND VPWR VPWR _7014_/X sky130_fd_sc_hd__mux2_1
X_4226_ _8953_/Q _4223_/X _4019_/X _4224_/X VGND VGND VPWR VPWR _8953_/D sky130_fd_sc_hd__a22o_1
XFILLER_110_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4157_ _6810_/X _6811_/X _6812_/X VGND VGND VPWR VPWR _5531_/A sky130_fd_sc_hd__or3_4
XFILLER_83_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8965_ _9029_/CLK _8965_/D VGND VGND VPWR VPWR _8965_/Q sky130_fd_sc_hd__dfxtp_1
X_4088_ _4088_/A VGND VGND VPWR VPWR _4088_/X sky130_fd_sc_hd__clkbuf_4
XFILLER_83_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7916_ _7912_/X _7913_/X _7914_/X _7915_/X _7996_/S0 _8001_/S1 VGND VGND VPWR VPWR
+ _7916_/X sky130_fd_sc_hd__mux4_2
XFILLER_83_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8896_ _8928_/CLK _8896_/D VGND VGND VPWR VPWR _8896_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7847_ _8599_/Q _8151_/Q _8503_/Q _8791_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7847_/X sky130_fd_sc_hd__mux4_2
XPHY_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7778_ _8276_/Q _8244_/Q _8212_/Q _9012_/Q _7875_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7778_/X sky130_fd_sc_hd__mux4_2
XFILLER_109_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6729_ _6728_/X _9079_/Q _6735_/S VGND VGND VPWR VPWR _6729_/X sky130_fd_sc_hd__mux2_4
Xclkbuf_leaf_112_clk clkbuf_4_2_0_clk/X VGND VGND VPWR VPWR _8729_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_11_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput25 imData[31] VGND VGND VPWR VPWR _3971_/A sky130_fd_sc_hd__clkbuf_1
XFILLER_128_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput14 imData[21] VGND VGND VPWR VPWR input14/X sky130_fd_sc_hd__buf_6
Xinput36 regAddr[3] VGND VGND VPWR VPWR input36/X sky130_fd_sc_hd__buf_8
Xclkbuf_leaf_103_clk _8032_/CLK VGND VGND VPWR VPWR _8950_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_111_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5060_ _5074_/A VGND VGND VPWR VPWR _5060_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4011_ _6805_/X VGND VGND VPWR VPWR _4599_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5962_ _7062_/X _5985_/B VGND VGND VPWR VPWR _5963_/A sky130_fd_sc_hd__nand2_1
X_8750_ _8782_/CLK _8750_/D VGND VGND VPWR VPWR _8750_/Q sky130_fd_sc_hd__dfxtp_1
X_4913_ _8555_/Q _4910_/X _4911_/X _4912_/X VGND VGND VPWR VPWR _8555_/D sky130_fd_sc_hd__a22o_1
X_7701_ _7697_/X _7698_/X _7699_/X _7700_/X _7701_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7701_/X sky130_fd_sc_hd__mux4_1
X_8681_ _8713_/CLK _8681_/D VGND VGND VPWR VPWR _8681_/Q sky130_fd_sc_hd__dfxtp_1
X_5893_ _5832_/A _5832_/B _5832_/D _5805_/B VGND VGND VPWR VPWR _5893_/X sky130_fd_sc_hd__o31a_1
X_4844_ _8587_/Q _4842_/X _4638_/X _4843_/X VGND VGND VPWR VPWR _8587_/D sky130_fd_sc_hd__a22o_1
X_7632_ _8813_/Q _8333_/Q _8941_/Q _8461_/Q _7659_/S0 _7657_/S1 VGND VGND VPWR VPWR
+ _7632_/X sky130_fd_sc_hd__mux4_2
XFILLER_20_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7563_ _8425_/Q _8297_/Q _8361_/Q _8553_/Q _7604_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7563_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4775_ _8634_/Q _4773_/X _4602_/X _4774_/X VGND VGND VPWR VPWR _8634_/D sky130_fd_sc_hd__a22o_1
X_6514_ _6514_/A VGND VGND VPWR VPWR _6514_/Y sky130_fd_sc_hd__inv_2
X_7494_ _8518_/Q _8902_/Q _8838_/Q _8870_/Q _7579_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7494_/X sky130_fd_sc_hd__mux4_1
XFILLER_134_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6445_ _7048_/X VGND VGND VPWR VPWR _6461_/A sky130_fd_sc_hd__inv_2
XFILLER_115_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6376_ _6196_/A _6375_/Y _6196_/A _6375_/Y VGND VGND VPWR VPWR _6376_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_88_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5327_ _8309_/Q _5325_/X _5159_/X _5326_/X VGND VGND VPWR VPWR _8309_/D sky130_fd_sc_hd__a22o_1
X_8115_ _8403_/CLK _8115_/D VGND VGND VPWR VPWR _8115_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_88_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8046_ _9037_/CLK _8046_/D VGND VGND VPWR VPWR _8046_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_87_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5258_ _8352_/Q _5229_/A _5208_/X _5230_/A VGND VGND VPWR VPWR _8352_/D sky130_fd_sc_hd__a22o_1
X_5189_ _8393_/Q _5182_/X _5188_/X _5184_/X VGND VGND VPWR VPWR _8393_/D sky130_fd_sc_hd__a22o_1
X_4209_ _4858_/A _4858_/B _4488_/C VGND VGND VPWR VPWR _5259_/A sky130_fd_sc_hd__or3_4
XFILLER_28_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8948_ _9013_/CLK _8948_/D VGND VGND VPWR VPWR _8948_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_83_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8879_ _8943_/CLK _8879_/D VGND VGND VPWR VPWR _8879_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4560_ _8754_/Q _4555_/X _4346_/X _4556_/X VGND VGND VPWR VPWR _8754_/D sky130_fd_sc_hd__a22o_1
XPHY_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4491_ _4507_/A VGND VGND VPWR VPWR _4491_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_6_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6230_ _6232_/B VGND VGND VPWR VPWR _6230_/Y sky130_fd_sc_hd__inv_2
XFILLER_131_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6161_ _9081_/Q _6161_/B VGND VGND VPWR VPWR _6162_/A sky130_fd_sc_hd__nand2_1
X_5112_ _8430_/Q _5108_/X _4904_/X _5109_/X VGND VGND VPWR VPWR _8430_/D sky130_fd_sc_hd__a22o_1
XFILLER_97_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6092_ _5951_/X _6983_/X VGND VGND VPWR VPWR _6092_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_112_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5043_ _8477_/Q _5037_/X _4868_/X _5040_/X VGND VGND VPWR VPWR _8477_/D sky130_fd_sc_hd__a22o_1
XFILLER_97_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8802_ _8933_/CLK _8802_/D VGND VGND VPWR VPWR _8802_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6994_ _5926_/Y _5917_/Y _7069_/S VGND VGND VPWR VPWR _6994_/X sky130_fd_sc_hd__mux2_4
XFILLER_19_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8733_ _8734_/CLK _8733_/D VGND VGND VPWR VPWR _8733_/Q sky130_fd_sc_hd__dfxtp_1
X_5945_ _6901_/X _5907_/X _5913_/X _5944_/Y VGND VGND VPWR VPWR _5945_/Y sky130_fd_sc_hd__o22ai_1
XFILLER_53_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5876_ _5875_/X _7004_/X VGND VGND VPWR VPWR _5876_/Y sky130_fd_sc_hd__nand2b_1
X_8664_ _8757_/CLK _8664_/D VGND VGND VPWR VPWR _8664_/Q sky130_fd_sc_hd__dfxtp_1
X_7615_ _8716_/Q _8684_/Q _8652_/Q _8620_/Q _7655_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7615_/X sky130_fd_sc_hd__mux4_2
X_4827_ _8598_/Q _4821_/X _4611_/X _4822_/X VGND VGND VPWR VPWR _8598_/D sky130_fd_sc_hd__a22o_1
XFILLER_119_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8595_ _8787_/CLK _8595_/D VGND VGND VPWR VPWR _8595_/Q sky130_fd_sc_hd__dfxtp_1
X_4758_ _8643_/Q _4753_/X _4657_/X _4754_/X VGND VGND VPWR VPWR _8643_/D sky130_fd_sc_hd__a22o_1
X_7546_ _7542_/X _7543_/X _7544_/X _7545_/X _8006_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _7546_/X sky130_fd_sc_hd__mux4_2
XFILLER_134_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7477_ _8581_/Q _8133_/Q _8485_/Q _8773_/Q _7480_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7477_/X sky130_fd_sc_hd__mux4_1
X_4689_ _8690_/Q _4684_/X _4621_/X _4685_/X VGND VGND VPWR VPWR _8690_/D sky130_fd_sc_hd__a22o_1
XFILLER_134_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6428_ _6428_/A _6428_/B VGND VGND VPWR VPWR _6428_/X sky130_fd_sc_hd__or2_1
XFILLER_134_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6359_ _6358_/X _6205_/X _6315_/X VGND VGND VPWR VPWR _6359_/X sky130_fd_sc_hd__o21a_1
XFILLER_102_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_9078_ _9078_/CLK _9078_/D repeater147/X VGND VGND VPWR VPWR _9078_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_130_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8029_ _8096_/Q _8064_/Q _8032_/Q _9024_/Q _8030_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _8029_/X sky130_fd_sc_hd__mux4_1
XFILLER_48_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_94_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3991_ _6606_/A _6109_/B _6814_/S VGND VGND VPWR VPWR _4210_/C sky130_fd_sc_hd__and3_1
XFILLER_74_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5730_ _8062_/Q _5725_/X _4593_/A _5728_/X VGND VGND VPWR VPWR _8062_/D sky130_fd_sc_hd__a22o_1
XFILLER_16_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5661_ _8107_/Q _5659_/X _5455_/X _5660_/X VGND VGND VPWR VPWR _8107_/D sky130_fd_sc_hd__a22o_1
X_7400_ _8961_/Q _8385_/Q _8161_/Q _8737_/Q _5771_/A _8030_/S1 VGND VGND VPWR VPWR
+ _7400_/X sky130_fd_sc_hd__mux4_1
XFILLER_31_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8380_ _8731_/CLK _8380_/D VGND VGND VPWR VPWR _8380_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_4_0_clk clkbuf_4_5_0_clk/A VGND VGND VPWR VPWR clkbuf_4_4_0_clk/X sky130_fd_sc_hd__clkbuf_1
X_5592_ _8154_/Q _5590_/X _5419_/X _5591_/X VGND VGND VPWR VPWR _8154_/D sky130_fd_sc_hd__a22o_1
X_4612_ _8726_/Q _4601_/X _4611_/X _4603_/X VGND VGND VPWR VPWR _8726_/D sky130_fd_sc_hd__a22o_1
XFILLER_129_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4543_ _8767_/Q _4539_/X _4393_/X _4542_/X VGND VGND VPWR VPWR _8767_/D sky130_fd_sc_hd__a22o_1
X_7331_ _7327_/X _7328_/X _7329_/X _7330_/X _7341_/S0 _7336_/S1 VGND VGND VPWR VPWR
+ _7331_/X sky130_fd_sc_hd__mux4_2
XFILLER_132_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_116_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7262_ _8819_/Q _8339_/Q _8947_/Q _8467_/Q _7288_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7262_/X sky130_fd_sc_hd__mux4_1
X_9001_ _9033_/CLK _9001_/D VGND VGND VPWR VPWR _9001_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_116_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4474_ _8811_/Q _4472_/X _4363_/X _4473_/X VGND VGND VPWR VPWR _8811_/D sky130_fd_sc_hd__a22o_1
XFILLER_89_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6213_ _6176_/A _6212_/Y _6217_/A _6212_/A VGND VGND VPWR VPWR _6214_/B sky130_fd_sc_hd__a22o_1
X_7193_ _8428_/Q _8300_/Q _8364_/Q _8556_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7193_/X sky130_fd_sc_hd__mux4_1
XFILLER_112_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6144_ _6264_/A _6263_/A _6144_/C _6276_/A VGND VGND VPWR VPWR _6255_/B sky130_fd_sc_hd__or4_4
XFILLER_112_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater220 _5771_/C VGND VGND VPWR VPWR _7996_/S0 sky130_fd_sc_hd__buf_6
XFILLER_100_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6075_ _5976_/A _6074_/X _5992_/A VGND VGND VPWR VPWR _6075_/X sky130_fd_sc_hd__o21a_1
XFILLER_58_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater231 _8000_/S1 VGND VGND VPWR VPWR _7595_/S1 sky130_fd_sc_hd__buf_8
Xrepeater242 _7995_/S0 VGND VGND VPWR VPWR _8000_/S0 sky130_fd_sc_hd__buf_6
X_5026_ _5026_/A VGND VGND VPWR VPWR _5026_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_85_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater253 _7659_/S0 VGND VGND VPWR VPWR _7655_/S0 sky130_fd_sc_hd__buf_8
Xrepeater275 _7611_/S0 VGND VGND VPWR VPWR _8006_/S0 sky130_fd_sc_hd__buf_8
Xrepeater264 _7049_/S VGND VGND VPWR VPWR _7070_/S sky130_fd_sc_hd__buf_8
Xclkbuf_leaf_92_clk clkbuf_4_8_0_clk/X VGND VGND VPWR VPWR _9078_/CLK sky130_fd_sc_hd__clkbuf_16
X_6977_ _7406_/X _7411_/X _7067_/S VGND VGND VPWR VPWR _6977_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5928_ _6886_/X _5907_/X _5913_/X _5927_/Y VGND VGND VPWR VPWR _5928_/Y sky130_fd_sc_hd__o22ai_1
X_8716_ _8876_/CLK _8716_/D VGND VGND VPWR VPWR _8716_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_81_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8647_ _8873_/CLK _8647_/D VGND VGND VPWR VPWR _8647_/Q sky130_fd_sc_hd__dfxtp_1
X_5859_ _6979_/X _5859_/B VGND VGND VPWR VPWR _5860_/B sky130_fd_sc_hd__nand2_1
XFILLER_70_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8578_ _8934_/CLK _8578_/D VGND VGND VPWR VPWR _8578_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_135_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_119_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7529_ _8103_/Q _8071_/Q _8039_/Q _9031_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7529_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_83_clk _8944_/CLK VGND VGND VPWR VPWR _8942_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_29_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4190_ _8973_/Q _4185_/X _4060_/X _4186_/X VGND VGND VPWR VPWR _8973_/D sky130_fd_sc_hd__a22o_1
XFILLER_67_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6900_ _6899_/X _6908_/X _6949_/S VGND VGND VPWR VPWR _6900_/X sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_74_clk clkbuf_opt_0_clk/A VGND VGND VPWR VPWR _9064_/CLK sky130_fd_sc_hd__clkbuf_16
X_7880_ _8985_/Q _8409_/Q _8185_/Q _8761_/Q _7900_/S0 _7900_/S1 VGND VGND VPWR VPWR
+ _7880_/X sky130_fd_sc_hd__mux4_1
XFILLER_47_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6831_ _6860_/X _6859_/X _6918_/S VGND VGND VPWR VPWR _6831_/X sky130_fd_sc_hd__mux2_1
XFILLER_35_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3974_ _3980_/A VGND VGND VPWR VPWR _3989_/A sky130_fd_sc_hd__clkbuf_2
X_6762_ _6374_/Y _6189_/Y _6777_/S VGND VGND VPWR VPWR _9072_/D sky130_fd_sc_hd__mux2_1
X_8501_ _9013_/CLK _8501_/D VGND VGND VPWR VPWR _8501_/Q sky130_fd_sc_hd__dfxtp_1
X_6693_ _6692_/X _9061_/Q _6743_/S VGND VGND VPWR VPWR _6693_/X sky130_fd_sc_hd__mux2_1
X_5713_ _8071_/Q _5707_/X _4647_/A _5708_/X VGND VGND VPWR VPWR _8071_/D sky130_fd_sc_hd__a22o_1
XFILLER_31_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8432_ _8782_/CLK _8432_/D VGND VGND VPWR VPWR _8432_/Q sky130_fd_sc_hd__dfxtp_1
X_5644_ _8118_/Q _5638_/X _5428_/X _5639_/X VGND VGND VPWR VPWR _8118_/D sky130_fd_sc_hd__a22o_1
XFILLER_31_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8363_ _8841_/CLK _8363_/D VGND VGND VPWR VPWR _8363_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5575_ _8163_/Q _5570_/X _5474_/X _5571_/X VGND VGND VPWR VPWR _8163_/D sky130_fd_sc_hd__a22o_1
X_7314_ _8536_/Q _8920_/Q _8856_/Q _8888_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7314_/X sky130_fd_sc_hd__mux4_2
X_8294_ _8868_/CLK _8294_/D VGND VGND VPWR VPWR _8294_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_105_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4526_ _8776_/Q _4521_/X _4370_/X _4522_/X VGND VGND VPWR VPWR _8776_/D sky130_fd_sc_hd__a22o_1
XFILLER_132_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7245_ _8721_/Q _8689_/Q _8657_/Q _8625_/Q _7369_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7245_/X sky130_fd_sc_hd__mux4_2
X_4457_ _8822_/Q _4451_/X _4336_/X _4452_/X VGND VGND VPWR VPWR _8822_/D sky130_fd_sc_hd__a22o_1
XFILLER_132_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7176_ _7172_/X _7173_/X _7174_/X _7175_/X _7191_/S0 _7191_/S1 VGND VGND VPWR VPWR
+ _7176_/X sky130_fd_sc_hd__mux4_2
XFILLER_86_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4388_ _4663_/A VGND VGND VPWR VPWR _4388_/X sky130_fd_sc_hd__clkbuf_2
X_6127_ _9071_/Q VGND VGND VPWR VPWR _6129_/A sky130_fd_sc_hd__inv_2
XFILLER_105_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6058_ _7000_/X _5882_/B _6658_/A _6030_/A _6035_/X VGND VGND VPWR VPWR _6059_/C
+ sky130_fd_sc_hd__a221o_1
XFILLER_58_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_65_clk clkbuf_4_14_0_clk/X VGND VGND VPWR VPWR _8876_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5009_ _8499_/Q _5005_/X _4892_/X _5006_/X VGND VGND VPWR VPWR _8499_/D sky130_fd_sc_hd__a22o_1
XFILLER_39_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_56_clk clkbuf_4_15_0_clk/X VGND VGND VPWR VPWR _8710_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_91_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5360_ _5374_/A VGND VGND VPWR VPWR _5360_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5291_ _5298_/A VGND VGND VPWR VPWR _5291_/X sky130_fd_sc_hd__clkbuf_2
X_4311_ _4537_/A _4938_/B VGND VGND VPWR VPWR _4374_/A sky130_fd_sc_hd__or2_4
XFILLER_114_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4242_ _8941_/Q _4237_/X _4060_/X _4238_/X VGND VGND VPWR VPWR _8941_/D sky130_fd_sc_hd__a22o_1
X_7030_ _6578_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7030_/X sky130_fd_sc_hd__mux2_2
XFILLER_68_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4173_ _8986_/Q _4171_/X _4015_/X _4172_/X VGND VGND VPWR VPWR _8986_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8981_ _8981_/CLK _8981_/D VGND VGND VPWR VPWR _8981_/Q sky130_fd_sc_hd__dfxtp_1
X_7932_ _8828_/Q _8348_/Q _8956_/Q _8476_/Q _7995_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7932_/X sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_47_clk clkbuf_4_13_0_clk/X VGND VGND VPWR VPWR _8999_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_36_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7863_ _8440_/Q _8312_/Q _8376_/Q _8568_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7863_/X sky130_fd_sc_hd__mux4_1
XPHY_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6814_ input3/X _7665_/S0 _6814_/S VGND VGND VPWR VPWR _6814_/X sky130_fd_sc_hd__mux2_1
X_7794_ _8533_/Q _8917_/Q _8853_/Q _8885_/Q _8030_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _7794_/X sky130_fd_sc_hd__mux4_1
X_6745_ _6744_/X _9087_/Q _6745_/S VGND VGND VPWR VPWR _6745_/X sky130_fd_sc_hd__mux2_1
XPHY_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8415_ _8991_/CLK _8415_/D VGND VGND VPWR VPWR _8415_/Q sky130_fd_sc_hd__dfxtp_1
X_6676_ _6523_/B _6661_/X _6523_/B _6661_/X VGND VGND VPWR VPWR _6676_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_31_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5627_ _5723_/A _5627_/B VGND VGND VPWR VPWR _5666_/A sky130_fd_sc_hd__or2_4
X_8346_ _8954_/CLK _8346_/D VGND VGND VPWR VPWR _8346_/Q sky130_fd_sc_hd__dfxtp_1
X_5558_ _8176_/Q _5556_/X _5443_/X _5557_/X VGND VGND VPWR VPWR _8176_/D sky130_fd_sc_hd__a22o_1
X_8277_ _9013_/CLK _8277_/D VGND VGND VPWR VPWR _8277_/Q sky130_fd_sc_hd__dfxtp_1
X_4509_ _8789_/Q _4507_/X _4339_/X _4508_/X VGND VGND VPWR VPWR _8789_/D sky130_fd_sc_hd__a22o_1
XFILLER_132_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5489_ _8223_/Q _5484_/X _5485_/X _5488_/X VGND VGND VPWR VPWR _8223_/D sky130_fd_sc_hd__a22o_1
X_7228_ _8271_/Q _8239_/Q _8207_/Q _9007_/Q _7240_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7228_/X sky130_fd_sc_hd__mux4_2
X_7159_ _8104_/Q _8072_/Q _8040_/Q _9032_/Q _7184_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7159_/X sky130_fd_sc_hd__mux4_2
XFILLER_98_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_38_clk clkbuf_4_7_0_clk/X VGND VGND VPWR VPWR _8456_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_92_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_29_clk clkbuf_4_5_0_clk/X VGND VGND VPWR VPWR _8734_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_17_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4860_ _4922_/A VGND VGND VPWR VPWR _4886_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_45_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_39 _6742_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6530_ _6839_/X _6673_/B _6529_/X VGND VGND VPWR VPWR _6531_/A sky130_fd_sc_hd__o21ai_2
X_4791_ _8622_/Q _4787_/X _4631_/X _4788_/X VGND VGND VPWR VPWR _8622_/D sky130_fd_sc_hd__a22o_1
XANTENNA_17 _5597_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_28 _6612_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6461_ _6461_/A _6461_/B VGND VGND VPWR VPWR _6462_/B sky130_fd_sc_hd__or2_1
X_8200_ _9061_/CLK _8200_/D VGND VGND VPWR VPWR _8200_/Q sky130_fd_sc_hd__dfxtp_1
X_5412_ _6807_/X VGND VGND VPWR VPWR _5412_/X sky130_fd_sc_hd__clkbuf_2
X_6392_ _6308_/B _6391_/X _6308_/B _6391_/X VGND VGND VPWR VPWR _6392_/Y sky130_fd_sc_hd__a2bb2oi_1
Xoutput102 _6701_/X VGND VGND VPWR VPWR regData[9] sky130_fd_sc_hd__clkbuf_2
XFILLER_133_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5343_ _8297_/Q _5339_/X _5188_/X _5340_/X VGND VGND VPWR VPWR _8297_/D sky130_fd_sc_hd__a22o_1
X_8131_ _9027_/CLK _8131_/D VGND VGND VPWR VPWR _8131_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_99_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8062_ _8725_/CLK _8062_/D VGND VGND VPWR VPWR _8062_/Q sky130_fd_sc_hd__dfxtp_1
X_5274_ _8344_/Q _5270_/X _5152_/X _5271_/X VGND VGND VPWR VPWR _8344_/D sky130_fd_sc_hd__a22o_1
XFILLER_102_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7013_ _7646_/X _7651_/X _7022_/S VGND VGND VPWR VPWR _7013_/X sky130_fd_sc_hd__mux2_1
X_4225_ _8954_/Q _4223_/X _4015_/X _4224_/X VGND VGND VPWR VPWR _8954_/D sky130_fd_sc_hd__a22o_1
XFILLER_56_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4156_ _8992_/Q _4127_/A _4103_/X _4128_/A VGND VGND VPWR VPWR _8992_/D sky130_fd_sc_hd__a22o_1
XFILLER_56_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4087_ _4653_/A VGND VGND VPWR VPWR _4087_/X sky130_fd_sc_hd__clkbuf_2
X_8964_ _9027_/CLK _8964_/D VGND VGND VPWR VPWR _8964_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_83_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7915_ _8731_/Q _8699_/Q _8667_/Q _8635_/Q _7995_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7915_/X sky130_fd_sc_hd__mux4_2
X_8895_ _8959_/CLK _8895_/D VGND VGND VPWR VPWR _8895_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_83_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7846_ _7842_/X _7843_/X _7844_/X _7845_/X _5872_/A _5873_/B VGND VGND VPWR VPWR
+ _7846_/X sky130_fd_sc_hd__mux4_1
XPHY_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4989_ _5005_/A VGND VGND VPWR VPWR _4989_/X sky130_fd_sc_hd__clkbuf_2
XPHY_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7777_ _8596_/Q _8148_/Q _8500_/Q _8788_/Q _7875_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7777_/X sky130_fd_sc_hd__mux4_1
XPHY_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6728_ _7306_/X _7311_/X _6734_/S VGND VGND VPWR VPWR _6728_/X sky130_fd_sc_hd__mux2_1
XFILLER_7_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6659_ _6832_/X _5946_/X _6100_/X _6658_/Y VGND VGND VPWR VPWR _6659_/Y sky130_fd_sc_hd__o22ai_1
X_8329_ _8841_/CLK _8329_/D VGND VGND VPWR VPWR _8329_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_118_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput26 imData[3] VGND VGND VPWR VPWR _6284_/A sky130_fd_sc_hd__buf_4
XPHY_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput15 imData[22] VGND VGND VPWR VPWR input15/X sky130_fd_sc_hd__buf_1
Xinput37 regAddr[4] VGND VGND VPWR VPWR _6714_/S sky130_fd_sc_hd__buf_4
XFILLER_116_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4010_ _9052_/Q _3998_/X _4009_/X _4003_/X VGND VGND VPWR VPWR _9052_/D sky130_fd_sc_hd__a22o_1
XFILLER_38_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5961_ _5994_/B VGND VGND VPWR VPWR _5985_/B sky130_fd_sc_hd__buf_2
XFILLER_52_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8680_ _8713_/CLK _8680_/D VGND VGND VPWR VPWR _8680_/Q sky130_fd_sc_hd__dfxtp_1
X_4912_ _4924_/A VGND VGND VPWR VPWR _4912_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_52_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7700_ _8976_/Q _8400_/Q _8176_/Q _8752_/Q _7700_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7700_/X sky130_fd_sc_hd__mux4_1
XFILLER_46_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5892_ _5875_/X _7001_/X VGND VGND VPWR VPWR _5892_/Y sky130_fd_sc_hd__nand2b_1
X_7631_ _7627_/X _7628_/X _7629_/X _7630_/X _6098_/A _6097_/A VGND VGND VPWR VPWR
+ _7631_/X sky130_fd_sc_hd__mux4_1
XFILLER_33_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4843_ _4850_/A VGND VGND VPWR VPWR _4843_/X sky130_fd_sc_hd__clkbuf_2
X_7562_ _8809_/Q _8329_/Q _8937_/Q _8457_/Q _7604_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7562_/X sky130_fd_sc_hd__mux4_1
X_4774_ _4781_/A VGND VGND VPWR VPWR _4774_/X sky130_fd_sc_hd__clkbuf_2
X_7493_ _8422_/Q _8294_/Q _8358_/Q _8550_/Q _7579_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7493_/X sky130_fd_sc_hd__mux4_1
X_6513_ _6513_/A _6513_/B _6513_/C _6513_/D VGND VGND VPWR VPWR _6514_/A sky130_fd_sc_hd__or4_4
XFILLER_107_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6444_ _7051_/X VGND VGND VPWR VPWR _6462_/A sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_9_clk clkbuf_4_1_0_clk/X VGND VGND VPWR VPWR _8821_/CLK sky130_fd_sc_hd__clkbuf_16
X_6375_ _6358_/X _6205_/A _6191_/X VGND VGND VPWR VPWR _6375_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_115_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8114_ _9044_/CLK _8114_/D VGND VGND VPWR VPWR _8114_/Q sky130_fd_sc_hd__dfxtp_1
X_5326_ _5326_/A VGND VGND VPWR VPWR _5326_/X sky130_fd_sc_hd__buf_2
XFILLER_130_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5257_ _8353_/Q _5229_/A _5206_/X _5230_/A VGND VGND VPWR VPWR _8353_/D sky130_fd_sc_hd__a22o_1
X_8045_ _9037_/CLK _8045_/D VGND VGND VPWR VPWR _8045_/Q sky130_fd_sc_hd__dfxtp_1
X_4208_ _6810_/X VGND VGND VPWR VPWR _4858_/A sky130_fd_sc_hd__inv_2
X_5188_ _6787_/X VGND VGND VPWR VPWR _5188_/X sky130_fd_sc_hd__clkbuf_2
X_4139_ _9005_/Q _4134_/X _4060_/X _4135_/X VGND VGND VPWR VPWR _9005_/D sky130_fd_sc_hd__a22o_1
XFILLER_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8947_ _8947_/CLK _8947_/D VGND VGND VPWR VPWR _8947_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_71_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8878_ _8942_/CLK _8878_/D VGND VGND VPWR VPWR _8878_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7829_ _8118_/Q _8086_/Q _8054_/Q _9046_/Q _7909_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7829_/X sky130_fd_sc_hd__mux4_2
XFILLER_138_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4490_ _4528_/A VGND VGND VPWR VPWR _4507_/A sky130_fd_sc_hd__buf_4
XFILLER_112_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6160_ _6160_/A VGND VGND VPWR VPWR _6161_/B sky130_fd_sc_hd__inv_2
XFILLER_112_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5111_ _8431_/Q _5108_/X _4902_/X _5109_/X VGND VGND VPWR VPWR _8431_/D sky130_fd_sc_hd__a22o_1
X_6091_ _6284_/A VGND VGND VPWR VPWR _6415_/A sky130_fd_sc_hd__inv_2
XFILLER_112_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5042_ _8478_/Q _5037_/X _4866_/X _5040_/X VGND VGND VPWR VPWR _8478_/D sky130_fd_sc_hd__a22o_1
XFILLER_85_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8801_ _8926_/CLK _8801_/D VGND VGND VPWR VPWR _8801_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_53_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6993_ _7516_/X _7521_/X _7071_/S VGND VGND VPWR VPWR _6993_/X sky130_fd_sc_hd__mux2_1
X_8732_ _8732_/CLK _8732_/D VGND VGND VPWR VPWR _8732_/Q sky130_fd_sc_hd__dfxtp_1
X_5944_ _5944_/A _5944_/B VGND VGND VPWR VPWR _5944_/Y sky130_fd_sc_hd__nor2_1
X_5875_ _6105_/A VGND VGND VPWR VPWR _5875_/X sky130_fd_sc_hd__buf_1
XFILLER_80_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8663_ _8665_/CLK _8663_/D VGND VGND VPWR VPWR _8663_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7614_ _8524_/Q _8908_/Q _8844_/Q _8876_/Q _7655_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7614_/X sky130_fd_sc_hd__mux4_1
X_4826_ _8599_/Q _4821_/X _4609_/X _4822_/X VGND VGND VPWR VPWR _8599_/D sky130_fd_sc_hd__a22o_1
XFILLER_21_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8594_ _8786_/CLK _8594_/D VGND VGND VPWR VPWR _8594_/Q sky130_fd_sc_hd__dfxtp_1
X_7545_ _8712_/Q _8680_/Q _8648_/Q _8616_/Q _7604_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7545_/X sky130_fd_sc_hd__mux4_2
X_4757_ _8644_/Q _4753_/X _4655_/X _4754_/X VGND VGND VPWR VPWR _8644_/D sky130_fd_sc_hd__a22o_1
XFILLER_119_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7476_ _7472_/X _7473_/X _7474_/X _7475_/X input16/X _7601_/S1 VGND VGND VPWR VPWR
+ _7476_/X sky130_fd_sc_hd__mux4_2
XFILLER_119_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4688_ _8691_/Q _4684_/X _4619_/X _4685_/X VGND VGND VPWR VPWR _8691_/D sky130_fd_sc_hd__a22o_1
X_6427_ _6427_/A _6427_/B _6427_/C _6427_/D VGND VGND VPWR VPWR _6428_/B sky130_fd_sc_hd__or4_4
X_6358_ _6358_/A VGND VGND VPWR VPWR _6358_/X sky130_fd_sc_hd__buf_1
XFILLER_115_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5309_ _5325_/A VGND VGND VPWR VPWR _5309_/X sky130_fd_sc_hd__buf_2
XFILLER_88_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6289_ _6289_/A VGND VGND VPWR VPWR _6289_/Y sky130_fd_sc_hd__inv_2
X_9077_ _9078_/CLK _9077_/D input38/X VGND VGND VPWR VPWR _9077_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_103_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8028_ _8256_/Q _8224_/Q _8192_/Q _8992_/Q _8030_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _8028_/X sky130_fd_sc_hd__mux4_1
XFILLER_124_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3990_ _6435_/B _5958_/A _5956_/A _3990_/D VGND VGND VPWR VPWR _6814_/S sky130_fd_sc_hd__and4_4
XFILLER_16_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5660_ _5667_/A VGND VGND VPWR VPWR _5660_/X sky130_fd_sc_hd__buf_2
XFILLER_31_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4611_ _4611_/A VGND VGND VPWR VPWR _4611_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_31_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5591_ _5598_/A VGND VGND VPWR VPWR _5591_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_129_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4542_ _4556_/A VGND VGND VPWR VPWR _4542_/X sky130_fd_sc_hd__clkbuf_2
X_7330_ _8985_/Q _8409_/Q _8185_/Q _8761_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7330_/X sky130_fd_sc_hd__mux4_1
X_4473_ _4480_/A VGND VGND VPWR VPWR _4473_/X sky130_fd_sc_hd__clkbuf_2
X_7261_ _7257_/X _7258_/X _7259_/X _7260_/X _7291_/S0 input36/X VGND VGND VPWR VPWR
+ _7261_/X sky130_fd_sc_hd__mux4_2
XFILLER_131_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9000_ _9000_/CLK _9000_/D VGND VGND VPWR VPWR _9000_/Q sky130_fd_sc_hd__dfxtp_1
X_6212_ _6212_/A VGND VGND VPWR VPWR _6212_/Y sky130_fd_sc_hd__inv_2
XFILLER_131_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7192_ _8812_/Q _8332_/Q _8940_/Q _8460_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7192_/X sky130_fd_sc_hd__mux4_1
X_6143_ _6143_/A _6143_/B _6143_/C _9059_/Q VGND VGND VPWR VPWR _6276_/A sky130_fd_sc_hd__or4b_4
XFILLER_100_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater210 _7053_/S VGND VGND VPWR VPWR _7071_/S sky130_fd_sc_hd__buf_8
X_6074_ _7051_/X _5974_/Y _5992_/B _5976_/B _5988_/X VGND VGND VPWR VPWR _6074_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_57_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrepeater221 input16/X VGND VGND VPWR VPWR _5771_/C sky130_fd_sc_hd__buf_8
X_5025_ _8487_/Q _5019_/X _4920_/X _5020_/X VGND VGND VPWR VPWR _8487_/D sky130_fd_sc_hd__a22o_1
Xrepeater243 _7975_/S0 VGND VGND VPWR VPWR _7995_/S0 sky130_fd_sc_hd__buf_8
Xrepeater232 _7995_/S1 VGND VGND VPWR VPWR _8000_/S1 sky130_fd_sc_hd__buf_8
Xrepeater276 input10/X VGND VGND VPWR VPWR _7611_/S0 sky130_fd_sc_hd__buf_8
Xrepeater265 _5873_/B VGND VGND VPWR VPWR _8021_/S1 sky130_fd_sc_hd__buf_6
Xrepeater254 _7700_/S0 VGND VGND VPWR VPWR _7659_/S0 sky130_fd_sc_hd__buf_8
X_6976_ _6093_/Y _3988_/B _7069_/S VGND VGND VPWR VPWR _6976_/X sky130_fd_sc_hd__mux2_4
XFILLER_53_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8715_ _8873_/CLK _8715_/D VGND VGND VPWR VPWR _8715_/Q sky130_fd_sc_hd__dfxtp_1
X_5927_ _5927_/A _6061_/B VGND VGND VPWR VPWR _5927_/Y sky130_fd_sc_hd__nor2_1
XFILLER_110_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8646_ _8709_/CLK _8646_/D VGND VGND VPWR VPWR _8646_/Q sky130_fd_sc_hd__dfxtp_1
X_5858_ _5947_/A _5858_/B VGND VGND VPWR VPWR _5859_/B sky130_fd_sc_hd__nor2_2
X_8577_ _8926_/CLK _8577_/D VGND VGND VPWR VPWR _8577_/Q sky130_fd_sc_hd__dfxtp_1
X_5789_ _6993_/X _6043_/B VGND VGND VPWR VPWR _5793_/A sky130_fd_sc_hd__nand2_2
X_4809_ _8608_/Q _4780_/A _4663_/X _4781_/A VGND VGND VPWR VPWR _8608_/D sky130_fd_sc_hd__a22o_1
XFILLER_135_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7528_ _8263_/Q _8231_/Q _8199_/Q _8999_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7528_/X sky130_fd_sc_hd__mux4_1
X_7459_ _8100_/Q _8068_/Q _8036_/Q _9028_/Q _7500_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7459_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6830_ _6660_/X _7021_/X _6830_/S VGND VGND VPWR VPWR _6830_/X sky130_fd_sc_hd__mux2_2
X_6761_ _6382_/Y _6227_/B _6777_/S VGND VGND VPWR VPWR _9071_/D sky130_fd_sc_hd__mux2_1
X_5712_ _8072_/Q _5707_/X _4645_/A _5708_/X VGND VGND VPWR VPWR _8072_/D sky130_fd_sc_hd__a22o_1
X_3973_ _5955_/A _5955_/B _3985_/A _3973_/D VGND VGND VPWR VPWR _6109_/B sky130_fd_sc_hd__or4_4
XFILLER_62_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8500_ _9013_/CLK _8500_/D VGND VGND VPWR VPWR _8500_/Q sky130_fd_sc_hd__dfxtp_1
X_6692_ _7126_/X _7131_/X _6714_/S VGND VGND VPWR VPWR _6692_/X sky130_fd_sc_hd__mux2_1
X_8431_ _8942_/CLK _8431_/D VGND VGND VPWR VPWR _8431_/Q sky130_fd_sc_hd__dfxtp_1
X_5643_ _8119_/Q _5638_/X _5426_/X _5639_/X VGND VGND VPWR VPWR _8119_/D sky130_fd_sc_hd__a22o_1
X_8362_ _8841_/CLK _8362_/D VGND VGND VPWR VPWR _8362_/Q sky130_fd_sc_hd__dfxtp_1
X_5574_ _8164_/Q _5570_/X _5472_/X _5571_/X VGND VGND VPWR VPWR _8164_/D sky130_fd_sc_hd__a22o_1
X_4525_ _8777_/Q _4521_/X _4368_/X _4522_/X VGND VGND VPWR VPWR _8777_/D sky130_fd_sc_hd__a22o_1
X_7313_ _8440_/Q _8312_/Q _8376_/Q _8568_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7313_/X sky130_fd_sc_hd__mux4_1
X_8293_ _8709_/CLK _8293_/D VGND VGND VPWR VPWR _8293_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4456_ _8823_/Q _4451_/X _4334_/X _4452_/X VGND VGND VPWR VPWR _8823_/D sky130_fd_sc_hd__a22o_1
X_7244_ _8529_/Q _8913_/Q _8849_/Q _8881_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7244_/X sky130_fd_sc_hd__mux4_2
X_7175_ _8714_/Q _8682_/Q _8650_/Q _8618_/Q _7185_/S0 _7185_/S1 VGND VGND VPWR VPWR
+ _7175_/X sky130_fd_sc_hd__mux4_1
XFILLER_131_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4387_ _8865_/Q _4338_/A _4386_/X _4340_/A VGND VGND VPWR VPWR _8865_/D sky130_fd_sc_hd__a22o_1
X_6126_ _9068_/Q VGND VGND VPWR VPWR _6234_/A sky130_fd_sc_hd__inv_2
X_6057_ _7018_/X VGND VGND VPWR VPWR _6658_/A sky130_fd_sc_hd__inv_2
XFILLER_27_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5008_ _8500_/Q _5005_/X _4890_/X _5006_/X VGND VGND VPWR VPWR _8500_/D sky130_fd_sc_hd__a22o_1
XFILLER_38_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6959_ _7039_/X _7042_/X _6963_/S VGND VGND VPWR VPWR _6959_/X sky130_fd_sc_hd__mux2_1
X_8629_ _8725_/CLK _8629_/D VGND VGND VPWR VPWR _8629_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_14_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_3_0_clk clkbuf_4_3_0_clk/A VGND VGND VPWR VPWR _8032_/CLK sky130_fd_sc_hd__clkbuf_1
XFILLER_76_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5290_ _8332_/Q _5284_/X _5180_/X _5285_/X VGND VGND VPWR VPWR _8332_/D sky130_fd_sc_hd__a22o_1
X_4310_ _8896_/Q _4281_/A _4103_/X _4282_/A VGND VGND VPWR VPWR _8896_/D sky130_fd_sc_hd__a22o_1
X_4241_ _8942_/Q _4237_/X _4057_/X _4238_/X VGND VGND VPWR VPWR _8942_/D sky130_fd_sc_hd__a22o_1
XFILLER_4_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4172_ _4179_/A VGND VGND VPWR VPWR _4172_/X sky130_fd_sc_hd__clkbuf_2
X_8980_ _9009_/CLK _8980_/D VGND VGND VPWR VPWR _8980_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_83_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7931_ _7927_/X _7928_/X _7929_/X _7930_/X _8011_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _7931_/X sky130_fd_sc_hd__mux4_1
XFILLER_82_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7862_ _8824_/Q _8344_/Q _8952_/Q _8472_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7862_/X sky130_fd_sc_hd__mux4_1
X_6813_ _6387_/Y _6099_/Y _6814_/S VGND VGND VPWR VPWR _6813_/X sky130_fd_sc_hd__mux2_1
X_7793_ _8437_/Q _8309_/Q _8373_/Q _8565_/Q _8030_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _7793_/X sky130_fd_sc_hd__mux4_2
XFILLER_23_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6744_ _7386_/X _7391_/X _6744_/S VGND VGND VPWR VPWR _6744_/X sky130_fd_sc_hd__mux2_1
XPHY_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6675_ _6666_/A _6666_/B _6666_/Y VGND VGND VPWR VPWR _6675_/X sky130_fd_sc_hd__a21o_1
XFILLER_50_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8414_ _8989_/CLK _8414_/D VGND VGND VPWR VPWR _8414_/Q sky130_fd_sc_hd__dfxtp_1
X_5626_ _8128_/Q _5597_/A _5480_/X _5598_/A VGND VGND VPWR VPWR _8128_/D sky130_fd_sc_hd__a22o_1
XFILLER_136_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5557_ _5571_/A VGND VGND VPWR VPWR _5557_/X sky130_fd_sc_hd__clkbuf_2
X_8345_ _8665_/CLK _8345_/D VGND VGND VPWR VPWR _8345_/Q sky130_fd_sc_hd__dfxtp_1
X_5488_ _5502_/A VGND VGND VPWR VPWR _5488_/X sky130_fd_sc_hd__clkbuf_2
X_8276_ _9012_/CLK _8276_/D VGND VGND VPWR VPWR _8276_/Q sky130_fd_sc_hd__dfxtp_1
X_4508_ _4508_/A VGND VGND VPWR VPWR _4508_/X sky130_fd_sc_hd__buf_2
XFILLER_105_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4439_ _5627_/B VGND VGND VPWR VPWR _5083_/A sky130_fd_sc_hd__buf_1
X_7227_ _8591_/Q _8143_/Q _8495_/Q _8783_/Q _7240_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7227_/X sky130_fd_sc_hd__mux4_1
XFILLER_120_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7158_ _8264_/Q _8232_/Q _8200_/Q _9000_/Q _7184_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7158_/X sky130_fd_sc_hd__mux4_2
XFILLER_86_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7089_ _8097_/Q _8065_/Q _8033_/Q _9025_/Q _7389_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7089_/X sky130_fd_sc_hd__mux4_2
X_6109_ _6110_/B _6109_/B VGND VGND VPWR VPWR _7069_/S sky130_fd_sc_hd__nand2_8
XFILLER_74_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_1976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4790_ _8623_/Q _4787_/X _4629_/X _4788_/X VGND VGND VPWR VPWR _8623_/D sky130_fd_sc_hd__a22o_1
XANTENNA_18 _5693_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_29 _6485_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6460_ _6460_/A _6460_/B VGND VGND VPWR VPWR _6461_/B sky130_fd_sc_hd__or2_1
XFILLER_127_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5411_ _8254_/Q _5405_/X _5410_/X _5408_/X VGND VGND VPWR VPWR _8254_/D sky130_fd_sc_hd__a22o_1
X_6391_ _6398_/A _6396_/A _6304_/Y _6261_/C VGND VGND VPWR VPWR _6391_/X sky130_fd_sc_hd__o31a_1
XFILLER_133_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5342_ _8298_/Q _5339_/X _5186_/X _5340_/X VGND VGND VPWR VPWR _8298_/D sky130_fd_sc_hd__a22o_1
X_8130_ _8998_/CLK _8130_/D VGND VGND VPWR VPWR _8130_/Q sky130_fd_sc_hd__dfxtp_1
X_8061_ _8725_/CLK _8061_/D VGND VGND VPWR VPWR _8061_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_99_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7012_ _6657_/Y _6238_/A _7069_/S VGND VGND VPWR VPWR _7012_/X sky130_fd_sc_hd__mux2_4
X_5273_ _8345_/Q _5270_/X _5150_/X _5271_/X VGND VGND VPWR VPWR _8345_/D sky130_fd_sc_hd__a22o_1
X_4224_ _4231_/A VGND VGND VPWR VPWR _4224_/X sky130_fd_sc_hd__clkbuf_2
X_4155_ _8993_/Q _4127_/A _4100_/X _4128_/A VGND VGND VPWR VPWR _8993_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8963_ _8966_/CLK _8963_/D VGND VGND VPWR VPWR _8963_/Q sky130_fd_sc_hd__dfxtp_1
X_4086_ _6783_/X VGND VGND VPWR VPWR _4653_/A sky130_fd_sc_hd__clkbuf_2
X_7914_ _8539_/Q _8923_/Q _8859_/Q _8891_/Q _8000_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7914_/X sky130_fd_sc_hd__mux4_2
X_8894_ _8958_/CLK _8894_/D VGND VGND VPWR VPWR _8894_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_70_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7845_ _8727_/Q _8695_/Q _8663_/Q _8631_/Q _7907_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7845_/X sky130_fd_sc_hd__mux4_2
XPHY_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4988_ _5026_/A VGND VGND VPWR VPWR _5005_/A sky130_fd_sc_hd__clkbuf_4
XPHY_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7776_ _7772_/X _7773_/X _7774_/X _7775_/X _8031_/S0 _8001_/S1 VGND VGND VPWR VPWR
+ _7776_/X sky130_fd_sc_hd__mux4_1
XFILLER_11_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6727_ _6726_/X _9078_/Q _6735_/S VGND VGND VPWR VPWR _6727_/X sky130_fd_sc_hd__mux2_8
XFILLER_109_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6658_ _6658_/A _6658_/B VGND VGND VPWR VPWR _6658_/Y sky130_fd_sc_hd__nor2_1
X_5609_ _8141_/Q _5604_/X _5450_/X _5605_/X VGND VGND VPWR VPWR _8141_/D sky130_fd_sc_hd__a22o_1
XFILLER_11_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8328_ _8456_/CLK _8328_/D VGND VGND VPWR VPWR _8328_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_105_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6589_ _6550_/A _6550_/B _6550_/D _6485_/B VGND VGND VPWR VPWR _6589_/X sky130_fd_sc_hd__o31a_1
XFILLER_11_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_133_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8259_ _9035_/CLK _8259_/D VGND VGND VPWR VPWR _8259_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_105_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput16 imData[23] VGND VGND VPWR VPWR input16/X sky130_fd_sc_hd__buf_6
Xinput27 imData[4] VGND VGND VPWR VPWR _5953_/A sky130_fd_sc_hd__clkbuf_4
XPHY_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput38 rst_n VGND VGND VPWR VPWR input38/X sky130_fd_sc_hd__clkbuf_4
XFILLER_109_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5960_ _7063_/X VGND VGND VPWR VPWR _6437_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_53_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4911_ _6789_/X VGND VGND VPWR VPWR _4911_/X sky130_fd_sc_hd__clkbuf_2
X_5891_ _6853_/X _5844_/X _5846_/X _5890_/Y VGND VGND VPWR VPWR _5891_/Y sky130_fd_sc_hd__o22ai_1
XFILLER_18_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7630_ _8972_/Q _8396_/Q _8172_/Q _8748_/Q _7665_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7630_/X sky130_fd_sc_hd__mux4_1
XFILLER_61_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4842_ _4849_/A VGND VGND VPWR VPWR _4842_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7561_ _7557_/X _7558_/X _7559_/X _7560_/X _5771_/C _7601_/S1 VGND VGND VPWR VPWR
+ _7561_/X sky130_fd_sc_hd__mux4_1
XFILLER_21_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4773_ _4780_/A VGND VGND VPWR VPWR _4773_/X sky130_fd_sc_hd__clkbuf_2
X_7492_ _8806_/Q _8326_/Q _8934_/Q _8454_/Q _7579_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7492_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6512_ _6512_/A _6512_/B _6541_/A VGND VGND VPWR VPWR _6512_/Y sky130_fd_sc_hd__nor3_2
XFILLER_119_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6443_ _7054_/X VGND VGND VPWR VPWR _6463_/A sky130_fd_sc_hd__inv_2
XFILLER_115_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6374_ _6358_/X _6205_/A _6358_/X _6205_/A VGND VGND VPWR VPWR _6374_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_88_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5325_ _5325_/A VGND VGND VPWR VPWR _5325_/X sky130_fd_sc_hd__buf_2
X_8113_ _8981_/CLK _8113_/D VGND VGND VPWR VPWR _8113_/Q sky130_fd_sc_hd__dfxtp_1
X_5256_ _8354_/Q _5250_/X _5204_/X _5251_/X VGND VGND VPWR VPWR _8354_/D sky130_fd_sc_hd__a22o_1
XFILLER_115_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8044_ _9004_/CLK _8044_/D VGND VGND VPWR VPWR _8044_/Q sky130_fd_sc_hd__dfxtp_1
X_4207_ _8960_/Q _4178_/A _4103_/X _4179_/A VGND VGND VPWR VPWR _8960_/D sky130_fd_sc_hd__a22o_1
XFILLER_130_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5187_ _8394_/Q _5182_/X _5186_/X _5184_/X VGND VGND VPWR VPWR _8394_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4138_ _9006_/Q _4134_/X _4057_/X _4135_/X VGND VGND VPWR VPWR _9006_/D sky130_fd_sc_hd__a22o_1
X_4069_ _6788_/X VGND VGND VPWR VPWR _4641_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_28_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8946_ _8947_/CLK _8946_/D VGND VGND VPWR VPWR _8946_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_44_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8877_ _8877_/CLK _8877_/D VGND VGND VPWR VPWR _8877_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7828_ _8278_/Q _8246_/Q _8214_/Q _9014_/Q _7909_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7828_/X sky130_fd_sc_hd__mux4_1
XPHY_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7759_ _8115_/Q _8083_/Q _8051_/Q _9043_/Q _7875_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7759_/X sky130_fd_sc_hd__mux4_2
XPHY_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_118_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_2260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6090_ _5951_/X _6986_/X VGND VGND VPWR VPWR _6090_/Y sky130_fd_sc_hd__nand2b_1
X_5110_ _8432_/Q _5108_/X _4899_/X _5109_/X VGND VGND VPWR VPWR _8432_/D sky130_fd_sc_hd__a22o_1
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5041_ _8479_/Q _5037_/X _4941_/X _5040_/X VGND VGND VPWR VPWR _8479_/D sky130_fd_sc_hd__a22o_1
XFILLER_81_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8800_ _8928_/CLK _8800_/D VGND VGND VPWR VPWR _8800_/Q sky130_fd_sc_hd__dfxtp_1
X_8731_ _8731_/CLK _8731_/D VGND VGND VPWR VPWR _8731_/Q sky130_fd_sc_hd__dfxtp_1
X_6992_ _7506_/X _7511_/X _7022_/S VGND VGND VPWR VPWR _6992_/X sky130_fd_sc_hd__mux2_2
X_5943_ _5943_/A VGND VGND VPWR VPWR _5944_/A sky130_fd_sc_hd__inv_2
XFILLER_80_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5874_ _6604_/A VGND VGND VPWR VPWR _6105_/A sky130_fd_sc_hd__buf_2
X_8662_ _8757_/CLK _8662_/D VGND VGND VPWR VPWR _8662_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7613_ _8428_/Q _8300_/Q _8364_/Q _8556_/Q _7655_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7613_/X sky130_fd_sc_hd__mux4_1
X_8593_ _8981_/CLK _8593_/D VGND VGND VPWR VPWR _8593_/Q sky130_fd_sc_hd__dfxtp_1
X_4825_ _8600_/Q _4821_/X _4607_/X _4822_/X VGND VGND VPWR VPWR _8600_/D sky130_fd_sc_hd__a22o_1
X_7544_ _8520_/Q _8904_/Q _8840_/Q _8872_/Q _7550_/S0 _7604_/S1 VGND VGND VPWR VPWR
+ _7544_/X sky130_fd_sc_hd__mux4_2
X_4756_ _8645_/Q _4753_/X _4653_/X _4754_/X VGND VGND VPWR VPWR _8645_/D sky130_fd_sc_hd__a22o_1
X_7475_ _8709_/Q _8677_/Q _8645_/Q _8613_/Q _7480_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7475_/X sky130_fd_sc_hd__mux4_1
XFILLER_107_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4687_ _8692_/Q _4684_/X _4617_/X _4685_/X VGND VGND VPWR VPWR _8692_/D sky130_fd_sc_hd__a22o_1
XFILLER_107_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6426_ _6800_/X _6799_/X _6798_/X _6797_/X VGND VGND VPWR VPWR _6427_/D sky130_fd_sc_hd__or4_4
X_6357_ _6326_/A _6356_/Y _6326_/A _6356_/Y VGND VGND VPWR VPWR _6357_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_88_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5308_ _5346_/A VGND VGND VPWR VPWR _5325_/A sky130_fd_sc_hd__clkbuf_4
XFILLER_103_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6288_ _6288_/A _6288_/B VGND VGND VPWR VPWR _6289_/A sky130_fd_sc_hd__or2_1
XFILLER_0_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9076_ _9078_/CLK _9076_/D repeater147/X VGND VGND VPWR VPWR _9076_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_57_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8027_ _8576_/Q _8128_/Q _8480_/Q _8768_/Q _8030_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _8027_/X sky130_fd_sc_hd__mux4_2
X_5239_ _8367_/Q _5236_/X _5174_/X _5237_/X VGND VGND VPWR VPWR _8367_/D sky130_fd_sc_hd__a22o_1
XFILLER_124_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8929_ _8929_/CLK _8929_/D VGND VGND VPWR VPWR _8929_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_25_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4610_ _8727_/Q _4601_/X _4609_/X _4603_/X VGND VGND VPWR VPWR _8727_/D sky130_fd_sc_hd__a22o_1
XPHY_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5590_ _5597_/A VGND VGND VPWR VPWR _5590_/X sky130_fd_sc_hd__clkbuf_2
X_4541_ _4577_/A VGND VGND VPWR VPWR _4556_/A sky130_fd_sc_hd__clkbuf_4
X_4472_ _4479_/A VGND VGND VPWR VPWR _4472_/X sky130_fd_sc_hd__clkbuf_2
X_7260_ _8978_/Q _8402_/Q _8178_/Q _8754_/Q _7288_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7260_/X sky130_fd_sc_hd__mux4_1
X_7191_ _7187_/X _7188_/X _7189_/X _7190_/X _7191_/S0 _7191_/S1 VGND VGND VPWR VPWR
+ _7191_/X sky130_fd_sc_hd__mux4_1
X_6211_ _6211_/A _6211_/B VGND VGND VPWR VPWR _6212_/A sky130_fd_sc_hd__or2_2
X_6142_ _9058_/Q VGND VGND VPWR VPWR _6143_/C sky130_fd_sc_hd__inv_2
XFILLER_97_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrepeater211 _7601_/S1 VGND VGND VPWR VPWR _7701_/S1 sky130_fd_sc_hd__buf_8
XFILLER_97_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6073_ _6073_/A VGND VGND VPWR VPWR _6073_/Y sky130_fd_sc_hd__inv_2
Xrepeater200 input33/X VGND VGND VPWR VPWR _7240_/S0 sky130_fd_sc_hd__buf_8
XFILLER_39_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater222 input16/X VGND VGND VPWR VPWR _7501_/S0 sky130_fd_sc_hd__buf_4
Xrepeater244 _7594_/S0 VGND VGND VPWR VPWR _7595_/S0 sky130_fd_sc_hd__buf_8
X_5024_ _8488_/Q _5019_/X _4918_/X _5020_/X VGND VGND VPWR VPWR _8488_/D sky130_fd_sc_hd__a22o_1
Xrepeater233 _7999_/S1 VGND VGND VPWR VPWR _7995_/S1 sky130_fd_sc_hd__buf_8
Xrepeater266 _8011_/S1 VGND VGND VPWR VPWR _5873_/B sky130_fd_sc_hd__buf_6
XFILLER_66_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater255 _7700_/S0 VGND VGND VPWR VPWR _7697_/S0 sky130_fd_sc_hd__buf_6
XFILLER_65_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6975_ _7396_/X _7401_/X _7071_/S VGND VGND VPWR VPWR _6975_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8714_ _8873_/CLK _8714_/D VGND VGND VPWR VPWR _8714_/Q sky130_fd_sc_hd__dfxtp_1
X_5926_ _5875_/X _6995_/X VGND VGND VPWR VPWR _5926_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_53_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8645_ _8709_/CLK _8645_/D VGND VGND VPWR VPWR _8645_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_34_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5857_ _6976_/X VGND VGND VPWR VPWR _5947_/A sky130_fd_sc_hd__inv_2
X_4808_ _8609_/Q _4780_/A _4661_/X _4781_/A VGND VGND VPWR VPWR _8609_/D sky130_fd_sc_hd__a22o_1
X_5788_ _6861_/X VGND VGND VPWR VPWR _5788_/Y sky130_fd_sc_hd__inv_2
X_8576_ _8928_/CLK _8576_/D VGND VGND VPWR VPWR _8576_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7527_ _8583_/Q _8135_/Q _8487_/Q _8775_/Q _7608_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7527_/X sky130_fd_sc_hd__mux4_1
X_4739_ _4753_/A VGND VGND VPWR VPWR _4739_/X sky130_fd_sc_hd__buf_2
XFILLER_134_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7458_ _8260_/Q _8228_/Q _8196_/Q _8996_/Q _7500_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7458_/X sky130_fd_sc_hd__mux4_1
XFILLER_135_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6409_ _6297_/C _6297_/B _6297_/C _6297_/B VGND VGND VPWR VPWR _6409_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_89_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7389_ _8127_/Q _8095_/Q _8063_/Q _9055_/Q _7389_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7389_/X sky130_fd_sc_hd__mux4_2
XFILLER_130_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9059_ _9061_/CLK _9059_/D repeater146/X VGND VGND VPWR VPWR _9059_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_0_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6760_ _6383_/Y _6230_/Y _6777_/S VGND VGND VPWR VPWR _9070_/D sky130_fd_sc_hd__mux2_1
X_5711_ _8073_/Q _5707_/X _4643_/A _5708_/X VGND VGND VPWR VPWR _8073_/D sky130_fd_sc_hd__a22o_1
X_3972_ _3973_/D _5955_/C _5955_/B _5955_/A VGND VGND VPWR VPWR _6606_/A sky130_fd_sc_hd__or4b_4
XFILLER_50_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6691_ _6690_/X _9060_/Q _6745_/S VGND VGND VPWR VPWR _6691_/X sky130_fd_sc_hd__mux2_2
X_8430_ _8941_/CLK _8430_/D VGND VGND VPWR VPWR _8430_/Q sky130_fd_sc_hd__dfxtp_1
X_5642_ _8120_/Q _5638_/X _5424_/X _5639_/X VGND VGND VPWR VPWR _8120_/D sky130_fd_sc_hd__a22o_1
XFILLER_129_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8361_ _8841_/CLK _8361_/D VGND VGND VPWR VPWR _8361_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5573_ _8165_/Q _5570_/X _5470_/X _5571_/X VGND VGND VPWR VPWR _8165_/D sky130_fd_sc_hd__a22o_1
X_4524_ _8778_/Q _4521_/X _4366_/X _4522_/X VGND VGND VPWR VPWR _8778_/D sky130_fd_sc_hd__a22o_1
XFILLER_117_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7312_ _8824_/Q _8344_/Q _8952_/Q _8472_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7312_/X sky130_fd_sc_hd__mux4_1
X_8292_ _9034_/CLK _8292_/D VGND VGND VPWR VPWR _8292_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_116_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4455_ _8824_/Q _4451_/X _4332_/X _4452_/X VGND VGND VPWR VPWR _8824_/D sky130_fd_sc_hd__a22o_1
X_7243_ _8433_/Q _8305_/Q _8369_/Q _8561_/Q _7288_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7243_/X sky130_fd_sc_hd__mux4_2
XFILLER_132_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7174_ _8522_/Q _8906_/Q _8842_/Q _8874_/Q _7185_/S0 _7185_/S1 VGND VGND VPWR VPWR
+ _7174_/X sky130_fd_sc_hd__mux4_1
X_4386_ _4661_/A VGND VGND VPWR VPWR _4386_/X sky130_fd_sc_hd__clkbuf_2
X_6125_ _9069_/Q VGND VGND VPWR VPWR _6223_/A sky130_fd_sc_hd__inv_2
XFILLER_112_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6056_ _6056_/A _6056_/B VGND VGND VPWR VPWR _6059_/B sky130_fd_sc_hd__nand2_1
XFILLER_65_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5007_ _8501_/Q _5005_/X _4887_/X _5006_/X VGND VGND VPWR VPWR _8501_/D sky130_fd_sc_hd__a22o_1
XFILLER_121_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6958_ _6960_/X _6959_/X _6961_/S VGND VGND VPWR VPWR _6958_/X sky130_fd_sc_hd__mux2_1
X_5909_ _6864_/X _5907_/X _5846_/X _5908_/Y VGND VGND VPWR VPWR _5909_/Y sky130_fd_sc_hd__o22ai_1
X_6889_ _6923_/X _6921_/X _6971_/S VGND VGND VPWR VPWR _6889_/X sky130_fd_sc_hd__mux2_1
X_8628_ _9051_/CLK _8628_/D VGND VGND VPWR VPWR _8628_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8559_ _8942_/CLK _8559_/D VGND VGND VPWR VPWR _8559_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_100_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4240_ _8943_/Q _4237_/X _4053_/X _4238_/X VGND VGND VPWR VPWR _8943_/D sky130_fd_sc_hd__a22o_1
XFILLER_122_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4171_ _4178_/A VGND VGND VPWR VPWR _4171_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_121_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7930_ _8987_/Q _8411_/Q _8187_/Q _8763_/Q _7949_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _7930_/X sky130_fd_sc_hd__mux4_1
X_7861_ _7857_/X _7858_/X _7859_/X _7860_/X _7901_/S0 _8031_/S1 VGND VGND VPWR VPWR
+ _7861_/X sky130_fd_sc_hd__mux4_2
X_6812_ _6238_/A _6098_/Y _6814_/S VGND VGND VPWR VPWR _6812_/X sky130_fd_sc_hd__mux2_2
XFILLER_35_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7792_ _8821_/Q _8341_/Q _8949_/Q _8469_/Q _8030_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _7792_/X sky130_fd_sc_hd__mux4_1
XFILLER_50_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6743_ _6742_/X _9086_/Q _6743_/S VGND VGND VPWR VPWR _6743_/X sky130_fd_sc_hd__mux2_1
XFILLER_23_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6674_ _6838_/X _5946_/X _6100_/X _6673_/Y VGND VGND VPWR VPWR _6674_/Y sky130_fd_sc_hd__o22ai_1
XFILLER_137_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8413_ _8989_/CLK _8413_/D VGND VGND VPWR VPWR _8413_/Q sky130_fd_sc_hd__dfxtp_1
X_5625_ _8129_/Q _5597_/A _5478_/X _5598_/A VGND VGND VPWR VPWR _8129_/D sky130_fd_sc_hd__a22o_1
X_5556_ _5570_/A VGND VGND VPWR VPWR _5556_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_3_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8344_ _8757_/CLK _8344_/D VGND VGND VPWR VPWR _8344_/Q sky130_fd_sc_hd__dfxtp_1
X_5487_ _5523_/A VGND VGND VPWR VPWR _5502_/A sky130_fd_sc_hd__buf_4
X_8275_ _8403_/CLK _8275_/D VGND VGND VPWR VPWR _8275_/Q sky130_fd_sc_hd__dfxtp_1
X_4507_ _4507_/A VGND VGND VPWR VPWR _4507_/X sky130_fd_sc_hd__buf_2
X_4438_ _8832_/Q _4409_/A _4388_/X _4410_/A VGND VGND VPWR VPWR _8832_/D sky130_fd_sc_hd__a22o_1
X_7226_ _7222_/X _7223_/X _7224_/X _7225_/X _7241_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7226_/X sky130_fd_sc_hd__mux4_1
X_4369_ _8873_/Q _4362_/X _4368_/X _4364_/X VGND VGND VPWR VPWR _8873_/D sky130_fd_sc_hd__a22o_1
XFILLER_101_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7157_ _8584_/Q _8136_/Q _8488_/Q _8776_/Q _7184_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7157_/X sky130_fd_sc_hd__mux4_2
XFILLER_98_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7088_ _8257_/Q _8225_/Q _8193_/Q _8993_/Q _7389_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7088_/X sky130_fd_sc_hd__mux4_1
X_6108_ _6572_/A VGND VGND VPWR VPWR _6110_/B sky130_fd_sc_hd__clkbuf_4
XFILLER_58_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6039_ _6452_/A VGND VGND VPWR VPWR _6677_/A sky130_fd_sc_hd__buf_1
XFILLER_58_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_115_clk clkbuf_4_0_0_clk/X VGND VGND VPWR VPWR _9009_/CLK sky130_fd_sc_hd__clkbuf_16
XPHY_1977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_19 _5715_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_13_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_106_clk clkbuf_4_2_0_clk/X VGND VGND VPWR VPWR _8954_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_9_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5410_ _6808_/X VGND VGND VPWR VPWR _5410_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6390_ _6388_/Y _6389_/Y _6388_/Y _6389_/Y VGND VGND VPWR VPWR _6390_/X sky130_fd_sc_hd__o2bb2a_1
X_5341_ _8299_/Q _5339_/X _5183_/X _5340_/X VGND VGND VPWR VPWR _8299_/D sky130_fd_sc_hd__a22o_1
XFILLER_114_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8060_ _9052_/CLK _8060_/D VGND VGND VPWR VPWR _8060_/Q sky130_fd_sc_hd__dfxtp_1
X_7011_ _7636_/X _7641_/X _7020_/S VGND VGND VPWR VPWR _7011_/X sky130_fd_sc_hd__mux2_1
X_5272_ _8346_/Q _5270_/X _5147_/X _5271_/X VGND VGND VPWR VPWR _8346_/D sky130_fd_sc_hd__a22o_1
X_4223_ _4230_/A VGND VGND VPWR VPWR _4223_/X sky130_fd_sc_hd__clkbuf_2
X_4154_ _8994_/Q _4148_/X _4097_/X _4149_/X VGND VGND VPWR VPWR _8994_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8962_ _9029_/CLK _8962_/D VGND VGND VPWR VPWR _8962_/Q sky130_fd_sc_hd__dfxtp_1
X_4085_ _4085_/A VGND VGND VPWR VPWR _4085_/X sky130_fd_sc_hd__clkbuf_4
XFILLER_68_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7913_ _8443_/Q _8315_/Q _8379_/Q _8571_/Q _7995_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7913_/X sky130_fd_sc_hd__mux4_1
X_8893_ _8958_/CLK _8893_/D VGND VGND VPWR VPWR _8893_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_64_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7844_ _8535_/Q _8919_/Q _8855_/Q _8887_/Q _7907_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7844_/X sky130_fd_sc_hd__mux4_1
XPHY_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7775_ _8724_/Q _8692_/Q _8660_/Q _8628_/Q _7919_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7775_/X sky130_fd_sc_hd__mux4_1
XFILLER_12_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4987_ _5210_/A _5579_/B VGND VGND VPWR VPWR _5026_/A sky130_fd_sc_hd__or2_4
XPHY_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6726_ _7296_/X _7301_/X _6734_/S VGND VGND VPWR VPWR _6726_/X sky130_fd_sc_hd__mux2_1
XFILLER_137_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6657_ _6604_/X _7013_/X VGND VGND VPWR VPWR _6657_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_118_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6588_ _6463_/A _6463_/B _6464_/B VGND VGND VPWR VPWR _6588_/X sky130_fd_sc_hd__a21bo_1
X_5608_ _8142_/Q _5604_/X _5448_/X _5605_/X VGND VGND VPWR VPWR _8142_/D sky130_fd_sc_hd__a22o_1
Xclkbuf_4_2_0_clk clkbuf_4_3_0_clk/A VGND VGND VPWR VPWR clkbuf_4_2_0_clk/X sky130_fd_sc_hd__clkbuf_1
XFILLER_118_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8327_ _8456_/CLK _8327_/D VGND VGND VPWR VPWR _8327_/Q sky130_fd_sc_hd__dfxtp_1
X_5539_ _8189_/Q _5533_/X _5412_/X _5536_/X VGND VGND VPWR VPWR _8189_/D sky130_fd_sc_hd__a22o_1
XFILLER_132_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8258_ _8998_/CLK _8258_/D VGND VGND VPWR VPWR _8258_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_78_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8189_ _9052_/CLK _8189_/D VGND VGND VPWR VPWR _8189_/Q sky130_fd_sc_hd__dfxtp_1
X_7209_ _8109_/Q _8077_/Q _8045_/Q _9037_/Q _7229_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7209_/X sky130_fd_sc_hd__mux4_1
XFILLER_74_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput28 imData[5] VGND VGND VPWR VPWR _3981_/A sky130_fd_sc_hd__clkbuf_4
XPHY_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput17 imData[24] VGND VGND VPWR VPWR input17/X sky130_fd_sc_hd__clkbuf_4
XPHY_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4910_ _4922_/A VGND VGND VPWR VPWR _4910_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_92_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5890_ _5890_/A _5890_/B VGND VGND VPWR VPWR _5890_/Y sky130_fd_sc_hd__nor2_1
X_4841_ _8588_/Q _4835_/X _4635_/X _4836_/X VGND VGND VPWR VPWR _8588_/D sky130_fd_sc_hd__a22o_1
XFILLER_61_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7560_ _8969_/Q _8393_/Q _8169_/Q _8745_/Q _7600_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7560_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4772_ _8635_/Q _4764_/X _4599_/X _4767_/X VGND VGND VPWR VPWR _8635_/D sky130_fd_sc_hd__a22o_1
X_7491_ _7487_/X _7488_/X _7489_/X _7490_/X input10/X _6097_/A VGND VGND VPWR VPWR
+ _7491_/X sky130_fd_sc_hd__mux4_1
X_6511_ _6511_/A _6511_/B VGND VGND VPWR VPWR _6541_/A sky130_fd_sc_hd__or2_2
XFILLER_119_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6442_ _7057_/X VGND VGND VPWR VPWR _6464_/A sky130_fd_sc_hd__inv_2
X_6373_ _6204_/X _6372_/X _6204_/X _6372_/X VGND VGND VPWR VPWR _6373_/Y sky130_fd_sc_hd__o2bb2ai_1
X_8112_ _9075_/CLK _8112_/D VGND VGND VPWR VPWR _8112_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_114_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5324_ _8310_/Q _5318_/X _5156_/X _5319_/X VGND VGND VPWR VPWR _8310_/D sky130_fd_sc_hd__a22o_1
X_5255_ _8355_/Q _5250_/X _5202_/X _5251_/X VGND VGND VPWR VPWR _8355_/D sky130_fd_sc_hd__a22o_1
XFILLER_114_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8043_ _9035_/CLK _8043_/D VGND VGND VPWR VPWR _8043_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_102_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4206_ _8961_/Q _4178_/A _4100_/X _4179_/A VGND VGND VPWR VPWR _8961_/D sky130_fd_sc_hd__a22o_1
X_5186_ _6788_/X VGND VGND VPWR VPWR _5186_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_110_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4137_ _9007_/Q _4134_/X _4053_/X _4135_/X VGND VGND VPWR VPWR _9007_/D sky130_fd_sc_hd__a22o_1
XFILLER_29_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4068_ _4085_/A VGND VGND VPWR VPWR _4068_/X sky130_fd_sc_hd__buf_2
XFILLER_83_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8945_ _8945_/CLK _8945_/D VGND VGND VPWR VPWR _8945_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_71_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8876_ _8876_/CLK _8876_/D VGND VGND VPWR VPWR _8876_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_37_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7827_ _8598_/Q _8150_/Q _8502_/Q _8790_/Q _7909_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7827_/X sky130_fd_sc_hd__mux4_2
XFILLER_52_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7758_ _8275_/Q _8243_/Q _8211_/Q _9011_/Q _7798_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7758_/X sky130_fd_sc_hd__mux4_2
XFILLER_11_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6709_ _6708_/X _9069_/Q _6743_/S VGND VGND VPWR VPWR _6709_/X sky130_fd_sc_hd__mux2_1
XPHY_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7689_ _8111_/Q _8079_/Q _8047_/Q _9039_/Q _7689_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7689_/X sky130_fd_sc_hd__mux4_1
XFILLER_11_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5040_ _5054_/A VGND VGND VPWR VPWR _5040_/X sky130_fd_sc_hd__buf_2
XFILLER_97_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6991_ _5941_/Y _5931_/Y _7069_/S VGND VGND VPWR VPWR _6991_/X sky130_fd_sc_hd__mux2_4
XFILLER_65_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5942_ _6979_/X VGND VGND VPWR VPWR _5943_/A sky130_fd_sc_hd__buf_2
XFILLER_53_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8730_ _9050_/CLK _8730_/D VGND VGND VPWR VPWR _8730_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_25_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8661_ _8725_/CLK _8661_/D VGND VGND VPWR VPWR _8661_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_61_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5873_ _7070_/S _5873_/B _5873_/C VGND VGND VPWR VPWR _6604_/A sky130_fd_sc_hd__nor3_4
X_7612_ _8812_/Q _8332_/Q _8940_/Q _8460_/Q _7655_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7612_/X sky130_fd_sc_hd__mux4_1
XFILLER_61_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8592_ _8782_/CLK _8592_/D VGND VGND VPWR VPWR _8592_/Q sky130_fd_sc_hd__dfxtp_1
X_4824_ _8601_/Q _4821_/X _4605_/X _4822_/X VGND VGND VPWR VPWR _8601_/D sky130_fd_sc_hd__a22o_1
XFILLER_33_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4755_ _8646_/Q _4753_/X _4650_/X _4754_/X VGND VGND VPWR VPWR _8646_/D sky130_fd_sc_hd__a22o_1
X_7543_ _8424_/Q _8296_/Q _8360_/Q _8552_/Q _8005_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7543_/X sky130_fd_sc_hd__mux4_2
XFILLER_21_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7474_ _8517_/Q _8901_/Q _8837_/Q _8869_/Q _7480_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7474_/X sky130_fd_sc_hd__mux4_2
X_4686_ _8693_/Q _4684_/X _4614_/X _4685_/X VGND VGND VPWR VPWR _8693_/D sky130_fd_sc_hd__a22o_1
XFILLER_134_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6425_ _6796_/X _6795_/X _6794_/X _6793_/X VGND VGND VPWR VPWR _6427_/C sky130_fd_sc_hd__or4_4
XFILLER_108_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6356_ _6318_/X _6333_/A _6321_/X VGND VGND VPWR VPWR _6356_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_102_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5307_ _5579_/A _5307_/B VGND VGND VPWR VPWR _5346_/A sky130_fd_sc_hd__or2_4
X_9075_ _9075_/CLK _9075_/D repeater147/X VGND VGND VPWR VPWR _9075_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_130_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6287_ _6288_/B VGND VGND VPWR VPWR _6287_/Y sky130_fd_sc_hd__inv_2
XFILLER_102_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8026_ _8022_/X _8023_/X _8024_/X _8025_/X _8031_/S0 _5771_/B VGND VGND VPWR VPWR
+ _8026_/X sky130_fd_sc_hd__mux4_1
XFILLER_130_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5238_ _8368_/Q _5236_/X _5171_/X _5237_/X VGND VGND VPWR VPWR _8368_/D sky130_fd_sc_hd__a22o_1
XFILLER_84_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_95_clk clkbuf_4_8_0_clk/X VGND VGND VPWR VPWR _8794_/CLK sky130_fd_sc_hd__clkbuf_16
X_5169_ _8401_/Q _5158_/X _5168_/X _5160_/X VGND VGND VPWR VPWR _8401_/D sky130_fd_sc_hd__a22o_1
XFILLER_17_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_84_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8928_ _8928_/CLK _8928_/D VGND VGND VPWR VPWR _8928_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8859_ _8959_/CLK _8859_/D VGND VGND VPWR VPWR _8859_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_71_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_86_clk _8944_/CLK VGND VGND VPWR VPWR _8816_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_90_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_2080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4540_ _4576_/A VGND VGND VPWR VPWR _4577_/A sky130_fd_sc_hd__inv_2
Xclkbuf_leaf_10_clk clkbuf_4_1_0_clk/X VGND VGND VPWR VPWR _8945_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_116_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4471_ _8812_/Q _4465_/X _4360_/X _4466_/X VGND VGND VPWR VPWR _8812_/D sky130_fd_sc_hd__a22o_1
X_7190_ _8971_/Q _8395_/Q _8171_/Q _8747_/Q _7190_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7190_/X sky130_fd_sc_hd__mux4_1
XFILLER_116_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6210_ _6154_/B _6154_/C _6154_/A VGND VGND VPWR VPWR _6211_/B sky130_fd_sc_hd__o21a_1
XFILLER_124_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6141_ _9056_/Q VGND VGND VPWR VPWR _6143_/B sky130_fd_sc_hd__inv_2
XFILLER_112_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6072_ _6035_/X _6051_/X _6085_/A _6070_/X _6071_/X VGND VGND VPWR VPWR _6072_/X
+ sky130_fd_sc_hd__o221a_1
Xrepeater201 _6949_/S VGND VGND VPWR VPWR _6918_/S sky130_fd_sc_hd__buf_4
Xrepeater212 _5771_/B VGND VGND VPWR VPWR _7601_/S1 sky130_fd_sc_hd__buf_8
X_5023_ _8489_/Q _5019_/X _4916_/X _5020_/X VGND VGND VPWR VPWR _8489_/D sky130_fd_sc_hd__a22o_1
Xrepeater223 _5772_/B VGND VGND VPWR VPWR _8030_/S1 sky130_fd_sc_hd__buf_6
Xrepeater234 _7780_/S1 VGND VGND VPWR VPWR _7999_/S1 sky130_fd_sc_hd__buf_8
XFILLER_38_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_77_clk clkbuf_opt_0_clk/A VGND VGND VPWR VPWR _8975_/CLK sky130_fd_sc_hd__clkbuf_16
Xrepeater267 _7611_/S1 VGND VGND VPWR VPWR _8011_/S1 sky130_fd_sc_hd__buf_8
Xrepeater245 _7594_/S0 VGND VGND VPWR VPWR _7975_/S0 sky130_fd_sc_hd__buf_6
Xrepeater256 _7875_/S0 VGND VGND VPWR VPWR _7798_/S0 sky130_fd_sc_hd__buf_8
XFILLER_26_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6974_ _6979_/X _6982_/X _6974_/S VGND VGND VPWR VPWR _6974_/X sky130_fd_sc_hd__mux2_1
XFILLER_65_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8713_ _8713_/CLK _8713_/D VGND VGND VPWR VPWR _8713_/Q sky130_fd_sc_hd__dfxtp_1
X_5925_ _5832_/A _5924_/A _5807_/A _5924_/Y VGND VGND VPWR VPWR _5925_/X sky130_fd_sc_hd__o22a_1
XFILLER_81_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8644_ _8710_/CLK _8644_/D VGND VGND VPWR VPWR _8644_/Q sky130_fd_sc_hd__dfxtp_1
X_5856_ _6982_/X VGND VGND VPWR VPWR _5927_/A sky130_fd_sc_hd__inv_2
XFILLER_139_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4807_ _8610_/Q _4801_/X _4659_/X _4802_/X VGND VGND VPWR VPWR _8610_/D sky130_fd_sc_hd__a22o_1
XFILLER_70_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8575_ _8735_/CLK _8575_/D VGND VGND VPWR VPWR _8575_/Q sky130_fd_sc_hd__dfxtp_1
X_5787_ _5787_/A VGND VGND VPWR VPWR _6513_/B sky130_fd_sc_hd__inv_2
X_7526_ _7522_/X _7523_/X _7524_/X _7525_/X _8006_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _7526_/X sky130_fd_sc_hd__mux4_2
X_4738_ _8657_/Q _4732_/X _4623_/X _4733_/X VGND VGND VPWR VPWR _8657_/D sky130_fd_sc_hd__a22o_1
XFILLER_134_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4669_ _4705_/A VGND VGND VPWR VPWR _4706_/A sky130_fd_sc_hd__inv_4
X_7457_ _8580_/Q _8132_/Q _8484_/Q _8772_/Q _7500_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7457_/X sky130_fd_sc_hd__mux4_2
XFILLER_134_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6408_ _6402_/A _6402_/B _6401_/A _6401_/Y _6402_/Y VGND VGND VPWR VPWR _6408_/X
+ sky130_fd_sc_hd__o32a_1
X_7388_ _8287_/Q _8255_/Q _8223_/Q _9023_/Q _7390_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7388_/X sky130_fd_sc_hd__mux4_2
XFILLER_103_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6339_ _6178_/X _6338_/Y _6114_/X _6338_/A VGND VGND VPWR VPWR _6339_/X sky130_fd_sc_hd__a22o_1
X_9058_ _9061_/CLK _9058_/D repeater146/X VGND VGND VPWR VPWR _9058_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_89_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8009_ _8127_/Q _8095_/Q _8063_/Q _9055_/Q _8015_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _8009_/X sky130_fd_sc_hd__mux4_2
Xclkbuf_leaf_68_clk clkbuf_4_14_0_clk/X VGND VGND VPWR VPWR _9004_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_29_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_59_clk clkbuf_4_15_0_clk/X VGND VGND VPWR VPWR _8933_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_48_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3971_ _3971_/A _3971_/B VGND VGND VPWR VPWR _5955_/B sky130_fd_sc_hd__or2_4
X_5710_ _8074_/Q _5707_/X _4641_/A _5708_/X VGND VGND VPWR VPWR _8074_/D sky130_fd_sc_hd__a22o_1
X_6690_ _7116_/X _7121_/X _6704_/S VGND VGND VPWR VPWR _6690_/X sky130_fd_sc_hd__mux2_2
X_5641_ _8121_/Q _5638_/X _5422_/X _5639_/X VGND VGND VPWR VPWR _8121_/D sky130_fd_sc_hd__a22o_1
XFILLER_117_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8360_ _8841_/CLK _8360_/D VGND VGND VPWR VPWR _8360_/Q sky130_fd_sc_hd__dfxtp_1
X_5572_ _8166_/Q _5570_/X _5467_/X _5571_/X VGND VGND VPWR VPWR _8166_/D sky130_fd_sc_hd__a22o_1
X_8291_ _9034_/CLK _8291_/D VGND VGND VPWR VPWR _8291_/Q sky130_fd_sc_hd__dfxtp_1
X_4523_ _8779_/Q _4521_/X _4363_/X _4522_/X VGND VGND VPWR VPWR _8779_/D sky130_fd_sc_hd__a22o_1
X_7311_ _7307_/X _7308_/X _7309_/X _7310_/X _7341_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7311_/X sky130_fd_sc_hd__mux4_1
XFILLER_117_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7242_ _8817_/Q _8337_/Q _8945_/Q _8465_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7242_/X sky130_fd_sc_hd__mux4_1
X_4454_ _8825_/Q _4451_/X _4330_/X _4452_/X VGND VGND VPWR VPWR _8825_/D sky130_fd_sc_hd__a22o_1
XFILLER_131_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7173_ _8426_/Q _8298_/Q _8362_/Q _8554_/Q _6343_/A _7185_/S1 VGND VGND VPWR VPWR
+ _7173_/X sky130_fd_sc_hd__mux4_2
X_4385_ _8866_/Q _4374_/X _4384_/X _4376_/X VGND VGND VPWR VPWR _8866_/D sky130_fd_sc_hd__a22o_1
XFILLER_131_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_86_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6124_ _9076_/Q VGND VGND VPWR VPWR _6154_/B sky130_fd_sc_hd__inv_2
X_6055_ _6452_/A _6041_/X _7003_/X _5849_/B _6054_/X VGND VGND VPWR VPWR _6056_/B
+ sky130_fd_sc_hd__o221a_1
X_5006_ _5006_/A VGND VGND VPWR VPWR _5006_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_39_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6957_ _6961_/X _6958_/X _6964_/S VGND VGND VPWR VPWR _6957_/X sky130_fd_sc_hd__mux2_1
XFILLER_81_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5908_ _5908_/A _5908_/B VGND VGND VPWR VPWR _5908_/Y sky130_fd_sc_hd__nor2_1
X_6888_ _6889_/X _5899_/B _6964_/S VGND VGND VPWR VPWR _6888_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8627_ _9051_/CLK _8627_/D VGND VGND VPWR VPWR _8627_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5839_ _6918_/S VGND VGND VPWR VPWR _6570_/A sky130_fd_sc_hd__clkbuf_2
X_8558_ _8941_/CLK _8558_/D VGND VGND VPWR VPWR _8558_/Q sky130_fd_sc_hd__dfxtp_1
X_7509_ _8102_/Q _8070_/Q _8038_/Q _9030_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7509_/X sky130_fd_sc_hd__mux4_1
XFILLER_135_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8489_ _9033_/CLK _8489_/D VGND VGND VPWR VPWR _8489_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_108_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4170_ _8987_/Q _4162_/X _4012_/X _4165_/X VGND VGND VPWR VPWR _8987_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7860_ _8984_/Q _8408_/Q _8184_/Q _8760_/Q _7894_/S0 _7900_/S1 VGND VGND VPWR VPWR
+ _7860_/X sky130_fd_sc_hd__mux4_1
XFILLER_35_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6811_ _6232_/A _6097_/Y _6814_/S VGND VGND VPWR VPWR _6811_/X sky130_fd_sc_hd__mux2_2
XFILLER_91_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7791_ _7787_/X _7788_/X _7789_/X _7790_/X _7811_/S0 _8021_/S1 VGND VGND VPWR VPWR
+ _7791_/X sky130_fd_sc_hd__mux4_2
X_6742_ _7376_/X _7381_/X _6744_/S VGND VGND VPWR VPWR _6742_/X sky130_fd_sc_hd__mux2_2
XFILLER_23_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6673_ _6673_/A _6673_/B VGND VGND VPWR VPWR _6673_/Y sky130_fd_sc_hd__nor2_1
X_5624_ _8130_/Q _5618_/X _5476_/X _5619_/X VGND VGND VPWR VPWR _8130_/D sky130_fd_sc_hd__a22o_1
X_8412_ _9020_/CLK _8412_/D VGND VGND VPWR VPWR _8412_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_31_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8343_ _8665_/CLK _8343_/D VGND VGND VPWR VPWR _8343_/Q sky130_fd_sc_hd__dfxtp_1
X_5555_ _8177_/Q _5549_/X _5440_/X _5550_/X VGND VGND VPWR VPWR _8177_/D sky130_fd_sc_hd__a22o_1
XFILLER_117_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5486_ _5522_/A VGND VGND VPWR VPWR _5523_/A sky130_fd_sc_hd__inv_2
X_8274_ _8787_/CLK _8274_/D VGND VGND VPWR VPWR _8274_/Q sky130_fd_sc_hd__dfxtp_1
X_4506_ _8790_/Q _4500_/X _4336_/X _4501_/X VGND VGND VPWR VPWR _8790_/D sky130_fd_sc_hd__a22o_1
XFILLER_132_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4437_ _8833_/Q _4409_/A _4386_/X _4410_/A VGND VGND VPWR VPWR _8833_/D sky130_fd_sc_hd__a22o_1
X_7225_ _8719_/Q _8687_/Q _8655_/Q _8623_/Q _7240_/S0 input34/X VGND VGND VPWR VPWR
+ _7225_/X sky130_fd_sc_hd__mux4_1
XFILLER_116_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7156_ _7152_/X _7153_/X _7154_/X _7155_/X _6343_/C _6343_/B VGND VGND VPWR VPWR
+ _7156_/X sky130_fd_sc_hd__mux4_1
X_4368_ _4643_/A VGND VGND VPWR VPWR _4368_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_113_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6107_ _6606_/A VGND VGND VPWR VPWR _6572_/A sky130_fd_sc_hd__buf_2
X_4299_ _8905_/Q _4295_/X _4074_/X _4296_/X VGND VGND VPWR VPWR _8905_/D sky130_fd_sc_hd__a22o_1
X_7087_ _8577_/Q _8129_/Q _8481_/Q _8769_/Q _7389_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7087_/X sky130_fd_sc_hd__mux4_1
X_6038_ _7009_/X VGND VGND VPWR VPWR _6452_/A sky130_fd_sc_hd__inv_2
XFILLER_73_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7989_ _8126_/Q _8094_/Q _8062_/Q _9054_/Q _8015_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7989_/X sky130_fd_sc_hd__mux4_1
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5340_ _5347_/A VGND VGND VPWR VPWR _5340_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5271_ _5278_/A VGND VGND VPWR VPWR _5271_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_114_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4222_ _8955_/Q _4214_/X _4012_/X _4217_/X VGND VGND VPWR VPWR _8955_/D sky130_fd_sc_hd__a22o_1
X_7010_ _7626_/X _7631_/X _7022_/S VGND VGND VPWR VPWR _7010_/X sky130_fd_sc_hd__mux2_1
XFILLER_68_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4153_ _8995_/Q _4148_/X _4094_/X _4149_/X VGND VGND VPWR VPWR _8995_/D sky130_fd_sc_hd__a22o_1
X_4084_ _9030_/Q _4068_/X _4083_/X _4071_/X VGND VGND VPWR VPWR _9030_/D sky130_fd_sc_hd__a22o_1
XFILLER_83_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8961_ _9054_/CLK _8961_/D VGND VGND VPWR VPWR _8961_/Q sky130_fd_sc_hd__dfxtp_1
X_7912_ _8827_/Q _8347_/Q _8955_/Q _8475_/Q _7995_/S0 _7995_/S1 VGND VGND VPWR VPWR
+ _7912_/X sky130_fd_sc_hd__mux4_1
XFILLER_83_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8892_ _8959_/CLK _8892_/D VGND VGND VPWR VPWR _8892_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_36_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7843_ _8439_/Q _8311_/Q _8375_/Q _8567_/Q _7907_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7843_/X sky130_fd_sc_hd__mux4_1
XFILLER_24_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4986_ _8512_/Q _4957_/A _4936_/X _4958_/A VGND VGND VPWR VPWR _8512_/D sky130_fd_sc_hd__a22o_1
XFILLER_51_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7774_ _8532_/Q _8916_/Q _8852_/Q _8884_/Q _7919_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7774_/X sky130_fd_sc_hd__mux4_1
XPHY_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6725_ _6724_/X _9077_/Q _6745_/S VGND VGND VPWR VPWR _6725_/X sky130_fd_sc_hd__mux2_2
XPHY_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6656_ _7024_/X _6655_/Y _6455_/B VGND VGND VPWR VPWR _6656_/Y sky130_fd_sc_hd__o21ai_1
X_6587_ _5842_/X _6584_/X _7003_/X _6572_/X _6586_/Y VGND VGND VPWR VPWR _6587_/Y
+ sky130_fd_sc_hd__o221ai_1
X_5607_ _8143_/Q _5604_/X _5446_/X _5605_/X VGND VGND VPWR VPWR _8143_/D sky130_fd_sc_hd__a22o_1
X_8326_ _8868_/CLK _8326_/D VGND VGND VPWR VPWR _8326_/Q sky130_fd_sc_hd__dfxtp_1
X_5538_ _8190_/Q _5533_/X _5410_/X _5536_/X VGND VGND VPWR VPWR _8190_/D sky130_fd_sc_hd__a22o_1
XFILLER_117_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8257_ _9055_/CLK _8257_/D VGND VGND VPWR VPWR _8257_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_105_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5469_ _8230_/Q _5466_/X _5467_/X _5468_/X VGND VGND VPWR VPWR _8230_/D sky130_fd_sc_hd__a22o_1
X_7208_ _8269_/Q _8237_/Q _8205_/Q _9005_/Q _7229_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7208_/X sky130_fd_sc_hd__mux4_2
XFILLER_133_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8188_ _9052_/CLK _8188_/D VGND VGND VPWR VPWR _8188_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_120_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7139_ _8102_/Q _8070_/Q _8038_/Q _9030_/Q _7140_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7139_/X sky130_fd_sc_hd__mux4_1
XFILLER_101_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 imData[25] VGND VGND VPWR VPWR _7053_/S sky130_fd_sc_hd__buf_2
XPHY_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput29 imData[6] VGND VGND VPWR VPWR input29/X sky130_fd_sc_hd__buf_1
XPHY_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4840_ _8589_/Q _4835_/X _4633_/X _4836_/X VGND VGND VPWR VPWR _8589_/D sky130_fd_sc_hd__a22o_1
XFILLER_61_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4771_ _8636_/Q _4764_/X _4597_/X _4767_/X VGND VGND VPWR VPWR _8636_/D sky130_fd_sc_hd__a22o_1
X_6510_ _6826_/X _6004_/Y _6509_/Y _6004_/A VGND VGND VPWR VPWR _6511_/B sky130_fd_sc_hd__a22o_1
X_7490_ _8965_/Q _8389_/Q _8165_/Q _8741_/Q _7645_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7490_/X sky130_fd_sc_hd__mux4_1
XFILLER_9_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6441_ _7060_/X VGND VGND VPWR VPWR _6465_/A sky130_fd_sc_hd__inv_2
XFILLER_134_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6372_ _6205_/C _6370_/X _6199_/X VGND VGND VPWR VPWR _6372_/X sky130_fd_sc_hd__o21a_1
XFILLER_127_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8111_ _8975_/CLK _8111_/D VGND VGND VPWR VPWR _8111_/Q sky130_fd_sc_hd__dfxtp_1
X_5323_ _8311_/Q _5318_/X _5154_/X _5319_/X VGND VGND VPWR VPWR _8311_/D sky130_fd_sc_hd__a22o_1
XFILLER_130_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5254_ _8356_/Q _5250_/X _5200_/X _5251_/X VGND VGND VPWR VPWR _8356_/D sky130_fd_sc_hd__a22o_1
X_8042_ _9034_/CLK _8042_/D VGND VGND VPWR VPWR _8042_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_115_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5185_ _8395_/Q _5182_/X _5183_/X _5184_/X VGND VGND VPWR VPWR _8395_/D sky130_fd_sc_hd__a22o_1
X_4205_ _8962_/Q _4199_/X _4097_/X _4200_/X VGND VGND VPWR VPWR _8962_/D sky130_fd_sc_hd__a22o_1
XFILLER_29_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4136_ _9008_/Q _4134_/X _4049_/X _4135_/X VGND VGND VPWR VPWR _9008_/D sky130_fd_sc_hd__a22o_1
XFILLER_113_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4067_ _9035_/Q _4051_/X _4066_/X _4054_/X VGND VGND VPWR VPWR _9035_/D sky130_fd_sc_hd__a22o_1
XFILLER_71_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8944_ _8944_/CLK _8944_/D VGND VGND VPWR VPWR _8944_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_44_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8875_ _8907_/CLK _8875_/D VGND VGND VPWR VPWR _8875_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_83_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7826_ _7822_/X _7823_/X _7824_/X _7825_/X _5872_/A _5873_/B VGND VGND VPWR VPWR
+ _7826_/X sky130_fd_sc_hd__mux4_1
XFILLER_52_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4969_ _8525_/Q _4964_/X _4906_/X _4965_/X VGND VGND VPWR VPWR _8525_/D sky130_fd_sc_hd__a22o_1
XPHY_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7757_ _8595_/Q _8147_/Q _8499_/Q _8787_/Q _7798_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7757_/X sky130_fd_sc_hd__mux4_1
X_6708_ _7206_/X _7211_/X _6714_/S VGND VGND VPWR VPWR _6708_/X sky130_fd_sc_hd__mux2_1
XPHY_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7688_ _8271_/Q _8239_/Q _8207_/Q _9007_/Q _7689_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7688_/X sky130_fd_sc_hd__mux4_1
XFILLER_22_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6639_ _6455_/A _6017_/Y _6621_/X VGND VGND VPWR VPWR _6639_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_118_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8309_ _8821_/CLK _8309_/D VGND VGND VPWR VPWR _8309_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_79_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6990_ _7496_/X _7501_/X _7020_/S VGND VGND VPWR VPWR _6990_/X sky130_fd_sc_hd__mux2_2
XFILLER_65_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_1_0_clk clkbuf_4_1_0_clk/A VGND VGND VPWR VPWR clkbuf_4_1_0_clk/X sky130_fd_sc_hd__clkbuf_1
X_5941_ _5875_/X _6992_/X VGND VGND VPWR VPWR _5941_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_65_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8660_ _9051_/CLK _8660_/D VGND VGND VPWR VPWR _8660_/Q sky130_fd_sc_hd__dfxtp_1
X_5872_ _5872_/A _5872_/B _5872_/C VGND VGND VPWR VPWR _5873_/C sky130_fd_sc_hd__or3_4
X_7611_ _7607_/X _7608_/X _7609_/X _7610_/X _7611_/S0 _7611_/S1 VGND VGND VPWR VPWR
+ _7611_/X sky130_fd_sc_hd__mux4_1
X_4823_ _8602_/Q _4821_/X _4602_/X _4822_/X VGND VGND VPWR VPWR _8602_/D sky130_fd_sc_hd__a22o_1
X_8591_ _8782_/CLK _8591_/D VGND VGND VPWR VPWR _8591_/Q sky130_fd_sc_hd__dfxtp_1
X_4754_ _4754_/A VGND VGND VPWR VPWR _4754_/X sky130_fd_sc_hd__clkbuf_2
X_7542_ _8808_/Q _8328_/Q _8936_/Q _8456_/Q _8005_/S0 _7604_/S1 VGND VGND VPWR VPWR
+ _7542_/X sky130_fd_sc_hd__mux4_1
X_7473_ _8421_/Q _8293_/Q _8357_/Q _8549_/Q _7480_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7473_/X sky130_fd_sc_hd__mux4_1
X_4685_ _4685_/A VGND VGND VPWR VPWR _4685_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_108_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6424_ _6808_/X _6807_/X _6806_/X _6805_/X VGND VGND VPWR VPWR _6427_/B sky130_fd_sc_hd__or4_4
X_6355_ _6318_/X _6333_/A _6318_/X _6333_/A VGND VGND VPWR VPWR _6355_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_130_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6286_ _9057_/Q _6291_/B _9058_/Q _6285_/X VGND VGND VPWR VPWR _6288_/B sky130_fd_sc_hd__a31o_1
X_5306_ _8320_/Q _5277_/A _5208_/X _5278_/A VGND VGND VPWR VPWR _8320_/D sky130_fd_sc_hd__a22o_1
XFILLER_0_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9074_ _9086_/CLK _9074_/D repeater147/X VGND VGND VPWR VPWR _9074_/Q sky130_fd_sc_hd__dfrtp_2
X_5237_ _5251_/A VGND VGND VPWR VPWR _5237_/X sky130_fd_sc_hd__clkbuf_2
X_8025_ _8704_/Q _8672_/Q _8640_/Q _8608_/Q _8025_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _8025_/X sky130_fd_sc_hd__mux4_1
XFILLER_76_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5168_ _6795_/X VGND VGND VPWR VPWR _5168_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_29_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4119_ _9019_/Q _4109_/X _4012_/X _4114_/X VGND VGND VPWR VPWR _9019_/D sky130_fd_sc_hd__a22o_1
XFILLER_17_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5099_ _8439_/Q _5094_/X _4882_/X _5095_/X VGND VGND VPWR VPWR _8439_/D sky130_fd_sc_hd__a22o_1
X_8927_ _8959_/CLK _8927_/D VGND VGND VPWR VPWR _8927_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_56_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8858_ _8922_/CLK _8858_/D VGND VGND VPWR VPWR _8858_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7809_ _8117_/Q _8085_/Q _8053_/Q _9045_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7809_/X sky130_fd_sc_hd__mux4_2
X_8789_ _9013_/CLK _8789_/D VGND VGND VPWR VPWR _8789_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_138_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4470_ _8813_/Q _4465_/X _4358_/X _4466_/X VGND VGND VPWR VPWR _8813_/D sky130_fd_sc_hd__a22o_1
X_6140_ _9057_/Q VGND VGND VPWR VPWR _6143_/A sky130_fd_sc_hd__inv_2
XFILLER_98_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6071_ _7018_/X _6658_/B VGND VGND VPWR VPWR _6071_/X sky130_fd_sc_hd__or2_1
Xrepeater202 _6932_/S VGND VGND VPWR VPWR _6964_/S sky130_fd_sc_hd__buf_6
X_5022_ _8490_/Q _5019_/X _4914_/X _5020_/X VGND VGND VPWR VPWR _8490_/D sky130_fd_sc_hd__a22o_1
Xrepeater213 _8001_/S1 VGND VGND VPWR VPWR _5771_/B sky130_fd_sc_hd__buf_8
Xrepeater224 _7657_/S1 VGND VGND VPWR VPWR _7700_/S1 sky130_fd_sc_hd__buf_8
XFILLER_57_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrepeater235 _7895_/S1 VGND VGND VPWR VPWR _7780_/S1 sky130_fd_sc_hd__buf_8
Xrepeater268 _6097_/A VGND VGND VPWR VPWR _7611_/S1 sky130_fd_sc_hd__buf_8
Xrepeater246 _7594_/S0 VGND VGND VPWR VPWR _5771_/A sky130_fd_sc_hd__buf_4
Xrepeater257 _7875_/S0 VGND VGND VPWR VPWR _7895_/S0 sky130_fd_sc_hd__buf_8
XFILLER_65_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6973_ _6985_/X _6988_/X _6974_/S VGND VGND VPWR VPWR _6973_/X sky130_fd_sc_hd__mux2_1
X_8712_ _8713_/CLK _8712_/D VGND VGND VPWR VPWR _8712_/Q sky130_fd_sc_hd__dfxtp_1
X_5924_ _5924_/A VGND VGND VPWR VPWR _5924_/Y sky130_fd_sc_hd__inv_2
XFILLER_80_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8643_ _8710_/CLK _8643_/D VGND VGND VPWR VPWR _8643_/Q sky130_fd_sc_hd__dfxtp_1
X_5855_ _6988_/X VGND VGND VPWR VPWR _5914_/A sky130_fd_sc_hd__inv_2
XFILLER_80_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4806_ _8611_/Q _4801_/X _4657_/X _4802_/X VGND VGND VPWR VPWR _8611_/D sky130_fd_sc_hd__a22o_1
XFILLER_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8574_ _8734_/CLK _8574_/D VGND VGND VPWR VPWR _8574_/Q sky130_fd_sc_hd__dfxtp_1
X_5786_ _5782_/Y _5785_/A _6854_/X _5890_/B VGND VGND VPWR VPWR _5787_/A sky130_fd_sc_hd__o22a_1
XFILLER_9_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7525_ _8711_/Q _8679_/Q _8647_/Q _8615_/Q input8/X _7985_/S1 VGND VGND VPWR VPWR
+ _7525_/X sky130_fd_sc_hd__mux4_2
X_4737_ _8658_/Q _4732_/X _4621_/X _4733_/X VGND VGND VPWR VPWR _8658_/D sky130_fd_sc_hd__a22o_1
X_7456_ _7452_/X _7453_/X _7454_/X _7455_/X input16/X _7601_/S1 VGND VGND VPWR VPWR
+ _7456_/X sky130_fd_sc_hd__mux4_2
XFILLER_119_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4668_ _4668_/A VGND VGND VPWR VPWR _4668_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_135_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6407_ _6297_/A _6406_/X _6297_/A _6406_/X VGND VGND VPWR VPWR _6407_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_134_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7387_ _8607_/Q _8159_/Q _8511_/Q _8799_/Q _7390_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7387_/X sky130_fd_sc_hd__mux4_1
X_4599_ _4599_/A VGND VGND VPWR VPWR _4599_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_0_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6338_ _6338_/A VGND VGND VPWR VPWR _6338_/Y sky130_fd_sc_hd__inv_2
X_9057_ _9057_/CLK _9057_/D repeater146/X VGND VGND VPWR VPWR _9057_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_89_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6269_ _6971_/S _6268_/B _6268_/Y VGND VGND VPWR VPWR _6269_/Y sky130_fd_sc_hd__a21oi_2
X_8008_ _8287_/Q _8255_/Q _8223_/Q _9023_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _8008_/X sky130_fd_sc_hd__mux4_1
XFILLER_29_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3970_ _3985_/A VGND VGND VPWR VPWR _5955_/C sky130_fd_sc_hd__inv_2
XFILLER_62_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5640_ _8122_/Q _5638_/X _5419_/X _5639_/X VGND VGND VPWR VPWR _8122_/D sky130_fd_sc_hd__a22o_1
XFILLER_129_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5571_ _5571_/A VGND VGND VPWR VPWR _5571_/X sky130_fd_sc_hd__clkbuf_2
X_8290_ _8934_/CLK _8290_/D VGND VGND VPWR VPWR _8290_/Q sky130_fd_sc_hd__dfxtp_1
X_4522_ _4529_/A VGND VGND VPWR VPWR _4522_/X sky130_fd_sc_hd__buf_2
X_7310_ _8983_/Q _8407_/Q _8183_/Q _8759_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7310_/X sky130_fd_sc_hd__mux4_1
XFILLER_8_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4453_ _8826_/Q _4451_/X _4327_/X _4452_/X VGND VGND VPWR VPWR _8826_/D sky130_fd_sc_hd__a22o_1
X_7241_ _7237_/X _7238_/X _7239_/X _7240_/X _7241_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7241_/X sky130_fd_sc_hd__mux4_2
XFILLER_131_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7172_ _8810_/Q _8330_/Q _8938_/Q _8458_/Q _7185_/S0 _7185_/S1 VGND VGND VPWR VPWR
+ _7172_/X sky130_fd_sc_hd__mux4_2
X_4384_ _4659_/A VGND VGND VPWR VPWR _4384_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_98_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6123_ _9077_/Q VGND VGND VPWR VPWR _6154_/A sky130_fd_sc_hd__inv_2
X_6054_ _7015_/X _6664_/B _5890_/A _5785_/A VGND VGND VPWR VPWR _6054_/X sky130_fd_sc_hd__o22a_1
X_5005_ _5005_/A VGND VGND VPWR VPWR _5005_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_54_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6956_ _7045_/X _7048_/X _6963_/S VGND VGND VPWR VPWR _6956_/X sky130_fd_sc_hd__mux2_1
XFILLER_54_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5907_ _5946_/A VGND VGND VPWR VPWR _5907_/X sky130_fd_sc_hd__clkbuf_2
X_6887_ _6890_/X _6888_/X _6918_/S VGND VGND VPWR VPWR _6887_/X sky130_fd_sc_hd__mux2_1
X_5838_ _6513_/C _5837_/A _5778_/A _5837_/Y VGND VGND VPWR VPWR _5838_/X sky130_fd_sc_hd__o22a_1
X_8626_ _9051_/CLK _8626_/D VGND VGND VPWR VPWR _8626_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5769_ _8033_/Q _5741_/A _4661_/A _5742_/A VGND VGND VPWR VPWR _8033_/D sky130_fd_sc_hd__a22o_1
X_8557_ _8940_/CLK _8557_/D VGND VGND VPWR VPWR _8557_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_135_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7508_ _8262_/Q _8230_/Q _8198_/Q _8998_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7508_/X sky130_fd_sc_hd__mux4_2
XFILLER_135_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8488_ _9056_/CLK _8488_/D VGND VGND VPWR VPWR _8488_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_5_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7439_ _8099_/Q _8067_/Q _8035_/Q _9027_/Q _7500_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7439_/X sky130_fd_sc_hd__mux4_1
XFILLER_116_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6810_ _6114_/X _6096_/Y _6814_/S VGND VGND VPWR VPWR _6810_/X sky130_fd_sc_hd__mux2_2
XFILLER_24_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7790_ _8980_/Q _8404_/Q _8180_/Q _8756_/Q _7885_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7790_/X sky130_fd_sc_hd__mux4_1
X_6741_ _6740_/X _9085_/Q _6741_/S VGND VGND VPWR VPWR _6741_/X sky130_fd_sc_hd__mux2_4
XFILLER_51_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6672_ _6523_/A _6671_/X _6523_/A _6671_/X VGND VGND VPWR VPWR _6672_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_50_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5623_ _8131_/Q _5618_/X _5474_/X _5619_/X VGND VGND VPWR VPWR _8131_/D sky130_fd_sc_hd__a22o_1
X_8411_ _9020_/CLK _8411_/D VGND VGND VPWR VPWR _8411_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_129_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8342_ _8822_/CLK _8342_/D VGND VGND VPWR VPWR _8342_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5554_ _8178_/Q _5549_/X _5438_/X _5550_/X VGND VGND VPWR VPWR _8178_/D sky130_fd_sc_hd__a22o_1
XFILLER_105_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5485_ _6809_/X VGND VGND VPWR VPWR _5485_/X sky130_fd_sc_hd__clkbuf_2
X_4505_ _8791_/Q _4500_/X _4334_/X _4501_/X VGND VGND VPWR VPWR _8791_/D sky130_fd_sc_hd__a22o_1
X_8273_ _9009_/CLK _8273_/D VGND VGND VPWR VPWR _8273_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_116_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4436_ _8834_/Q _4430_/X _4384_/X _4431_/X VGND VGND VPWR VPWR _8834_/D sky130_fd_sc_hd__a22o_1
X_7224_ _8527_/Q _8911_/Q _8847_/Q _8879_/Q _7240_/S0 input34/X VGND VGND VPWR VPWR
+ _7224_/X sky130_fd_sc_hd__mux4_1
X_7155_ _8712_/Q _8680_/Q _8648_/Q _8616_/Q _7185_/S0 _7185_/S1 VGND VGND VPWR VPWR
+ _7155_/X sky130_fd_sc_hd__mux4_2
X_4367_ _8874_/Q _4362_/X _4366_/X _4364_/X VGND VGND VPWR VPWR _8874_/D sky130_fd_sc_hd__a22o_1
XFILLER_113_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6106_ _6105_/X _7070_/X VGND VGND VPWR VPWR _6106_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_76_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4298_ _8906_/Q _4295_/X _4070_/X _4296_/X VGND VGND VPWR VPWR _8906_/D sky130_fd_sc_hd__a22o_1
X_7086_ _7082_/X _7083_/X _7084_/X _7085_/X _7391_/S0 _7381_/S1 VGND VGND VPWR VPWR
+ _7086_/X sky130_fd_sc_hd__mux4_2
XFILLER_58_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6037_ _7011_/X _6037_/B VGND VGND VPWR VPWR _6518_/A sky130_fd_sc_hd__nand2_2
XFILLER_58_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7988_ _8286_/Q _8254_/Q _8222_/Q _9022_/Q _7990_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7988_/X sky130_fd_sc_hd__mux4_1
XFILLER_54_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6939_ _6941_/X _6940_/X _6939_/S VGND VGND VPWR VPWR _6939_/X sky130_fd_sc_hd__mux2_1
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8609_ _9056_/CLK _8609_/D VGND VGND VPWR VPWR _8609_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5270_ _5277_/A VGND VGND VPWR VPWR _5270_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_99_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4221_ _8956_/Q _4214_/X _4009_/X _4217_/X VGND VGND VPWR VPWR _8956_/D sky130_fd_sc_hd__a22o_1
XFILLER_96_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4152_ _8996_/Q _4148_/X _4091_/X _4149_/X VGND VGND VPWR VPWR _8996_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4083_ _4650_/A VGND VGND VPWR VPWR _4083_/X sky130_fd_sc_hd__buf_2
XFILLER_68_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8960_ _8960_/CLK _8960_/D VGND VGND VPWR VPWR _8960_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_56_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7911_ _7907_/X _7908_/X _7909_/X _7910_/X _5872_/A input11/X VGND VGND VPWR VPWR
+ _7911_/X sky130_fd_sc_hd__mux4_2
XFILLER_36_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8891_ _8959_/CLK _8891_/D VGND VGND VPWR VPWR _8891_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_70_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7842_ _8823_/Q _8343_/Q _8951_/Q _8471_/Q _7907_/S0 _7904_/S1 VGND VGND VPWR VPWR
+ _7842_/X sky130_fd_sc_hd__mux4_1
XFILLER_24_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4985_ _8513_/Q _4957_/A _4934_/X _4958_/A VGND VGND VPWR VPWR _8513_/D sky130_fd_sc_hd__a22o_1
X_7773_ _8436_/Q _8308_/Q _8372_/Q _8564_/Q _7919_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7773_/X sky130_fd_sc_hd__mux4_2
XPHY_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6724_ _7286_/X _7291_/X _6734_/S VGND VGND VPWR VPWR _6724_/X sky130_fd_sc_hd__mux2_2
X_6655_ _6655_/A _6655_/B VGND VGND VPWR VPWR _6655_/Y sky130_fd_sc_hd__nor2_1
XFILLER_31_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6586_ _6462_/A _5974_/Y _6585_/X VGND VGND VPWR VPWR _6586_/Y sky130_fd_sc_hd__o21ai_1
X_5606_ _8144_/Q _5604_/X _5443_/X _5605_/X VGND VGND VPWR VPWR _8144_/D sky130_fd_sc_hd__a22o_1
X_8325_ _8709_/CLK _8325_/D VGND VGND VPWR VPWR _8325_/Q sky130_fd_sc_hd__dfxtp_1
X_5537_ _8191_/Q _5533_/X _5485_/X _5536_/X VGND VGND VPWR VPWR _8191_/D sky130_fd_sc_hd__a22o_1
XFILLER_11_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8256_ _9024_/CLK _8256_/D VGND VGND VPWR VPWR _8256_/Q sky130_fd_sc_hd__dfxtp_1
X_7207_ _8589_/Q _8141_/Q _8493_/Q _8781_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7207_/X sky130_fd_sc_hd__mux4_1
X_5468_ _5468_/A VGND VGND VPWR VPWR _5468_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_120_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5399_ _8259_/Q _5394_/X _5202_/X _5395_/X VGND VGND VPWR VPWR _8259_/D sky130_fd_sc_hd__a22o_1
XFILLER_87_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8187_ _9052_/CLK _8187_/D VGND VGND VPWR VPWR _8187_/Q sky130_fd_sc_hd__dfxtp_1
X_4419_ _8847_/Q _4416_/X _4354_/X _4417_/X VGND VGND VPWR VPWR _8847_/D sky130_fd_sc_hd__a22o_1
XFILLER_101_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7138_ _8262_/Q _8230_/Q _8198_/Q _8998_/Q _7140_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7138_/X sky130_fd_sc_hd__mux4_1
X_7069_ _6106_/Y _6291_/A _7069_/S VGND VGND VPWR VPWR _7069_/X sky130_fd_sc_hd__mux2_4
XFILLER_36_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput19 imData[26] VGND VGND VPWR VPWR _3976_/B sky130_fd_sc_hd__buf_2
XFILLER_109_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4770_ _8637_/Q _4764_/X _4595_/X _4767_/X VGND VGND VPWR VPWR _8637_/D sky130_fd_sc_hd__a22o_1
XFILLER_14_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6440_ _6434_/X _6436_/X _7015_/X _6110_/B _6439_/Y VGND VGND VPWR VPWR _6440_/Y
+ sky130_fd_sc_hd__o221ai_2
XFILLER_9_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6371_ _6205_/C _6370_/X _6205_/C _6370_/X VGND VGND VPWR VPWR _6371_/Y sky130_fd_sc_hd__a2bb2oi_1
X_8110_ _9038_/CLK _8110_/D VGND VGND VPWR VPWR _8110_/Q sky130_fd_sc_hd__dfxtp_1
X_5322_ _8312_/Q _5318_/X _5152_/X _5319_/X VGND VGND VPWR VPWR _8312_/D sky130_fd_sc_hd__a22o_1
X_5253_ _8357_/Q _5250_/X _5198_/X _5251_/X VGND VGND VPWR VPWR _8357_/D sky130_fd_sc_hd__a22o_1
X_8041_ _9034_/CLK _8041_/D VGND VGND VPWR VPWR _8041_/Q sky130_fd_sc_hd__dfxtp_1
X_4204_ _8963_/Q _4199_/X _4094_/X _4200_/X VGND VGND VPWR VPWR _8963_/D sky130_fd_sc_hd__a22o_1
X_5184_ _5196_/A VGND VGND VPWR VPWR _5184_/X sky130_fd_sc_hd__clkbuf_2
X_4135_ _4149_/A VGND VGND VPWR VPWR _4135_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_3_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_113_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4066_ _4638_/A VGND VGND VPWR VPWR _4066_/X sky130_fd_sc_hd__buf_2
XFILLER_37_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8943_ _8943_/CLK _8943_/D VGND VGND VPWR VPWR _8943_/Q sky130_fd_sc_hd__dfxtp_1
X_8874_ _8938_/CLK _8874_/D VGND VGND VPWR VPWR _8874_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_37_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7825_ _8726_/Q _8694_/Q _8662_/Q _8630_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7825_/X sky130_fd_sc_hd__mux4_2
XPHY_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4968_ _8526_/Q _4964_/X _4904_/X _4965_/X VGND VGND VPWR VPWR _8526_/D sky130_fd_sc_hd__a22o_1
XPHY_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7756_ _7752_/X _7753_/X _7754_/X _7755_/X _7801_/S0 _8001_/S1 VGND VGND VPWR VPWR
+ _7756_/X sky130_fd_sc_hd__mux4_1
X_6707_ _6706_/X _9068_/Q _6743_/S VGND VGND VPWR VPWR _6707_/X sky130_fd_sc_hd__mux2_2
XPHY_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7687_ _8591_/Q _8143_/Q _8495_/Q _8783_/Q _7710_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7687_/X sky130_fd_sc_hd__mux4_2
X_4899_ _6794_/X VGND VGND VPWR VPWR _4899_/X sky130_fd_sc_hd__clkbuf_2
X_6638_ _6501_/B _6637_/Y _6495_/A _6637_/A VGND VGND VPWR VPWR _6638_/X sky130_fd_sc_hd__o22a_1
XFILLER_125_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6569_ _6470_/X _6554_/X _6470_/X _6554_/X VGND VGND VPWR VPWR _6569_/Y sky130_fd_sc_hd__a2bb2oi_1
X_8308_ _8882_/CLK _8308_/D VGND VGND VPWR VPWR _8308_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_3_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8239_ _9067_/CLK _8239_/D VGND VGND VPWR VPWR _8239_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_121_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5940_ _5934_/X _5939_/X _5934_/X _5939_/X VGND VGND VPWR VPWR _5940_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_80_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7610_ _8971_/Q _8395_/Q _8171_/Q _8747_/Q _7610_/S0 _7610_/S1 VGND VGND VPWR VPWR
+ _7610_/X sky130_fd_sc_hd__mux4_1
X_5871_ _7006_/X _5867_/Y _6452_/C VGND VGND VPWR VPWR _5871_/Y sky130_fd_sc_hd__o21ai_1
X_8590_ _8781_/CLK _8590_/D VGND VGND VPWR VPWR _8590_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_33_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4822_ _4829_/A VGND VGND VPWR VPWR _4822_/X sky130_fd_sc_hd__clkbuf_2
X_4753_ _4753_/A VGND VGND VPWR VPWR _4753_/X sky130_fd_sc_hd__clkbuf_2
X_7541_ _7537_/X _7538_/X _7539_/X _7540_/X _5771_/C _7601_/S1 VGND VGND VPWR VPWR
+ _7541_/X sky130_fd_sc_hd__mux4_1
X_7472_ _8805_/Q _8325_/Q _8933_/Q _8453_/Q _7480_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7472_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4684_ _4684_/A VGND VGND VPWR VPWR _4684_/X sky130_fd_sc_hd__clkbuf_2
X_6423_ _6804_/X _6803_/X _6802_/X _6801_/X VGND VGND VPWR VPWR _6427_/A sky130_fd_sc_hd__or4_4
X_6354_ _6105_/X _7061_/X VGND VGND VPWR VPWR _6354_/Y sky130_fd_sc_hd__nand2b_1
X_5305_ _8321_/Q _5277_/A _5206_/X _5278_/A VGND VGND VPWR VPWR _8321_/D sky130_fd_sc_hd__a22o_1
X_6285_ _6143_/A _6143_/B _6143_/C VGND VGND VPWR VPWR _6285_/X sky130_fd_sc_hd__o21a_1
X_9073_ _9075_/CLK _9073_/D repeater147/X VGND VGND VPWR VPWR _9073_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_103_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5236_ _5250_/A VGND VGND VPWR VPWR _5236_/X sky130_fd_sc_hd__clkbuf_2
X_8024_ _8512_/Q _8896_/Q _8832_/Q _8864_/Q _8025_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _8024_/X sky130_fd_sc_hd__mux4_1
XFILLER_124_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5167_ _8402_/Q _5158_/X _5166_/X _5160_/X VGND VGND VPWR VPWR _8402_/D sky130_fd_sc_hd__a22o_1
XFILLER_96_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4118_ _9020_/Q _4109_/X _4009_/X _4114_/X VGND VGND VPWR VPWR _9020_/D sky130_fd_sc_hd__a22o_1
XFILLER_56_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5098_ _8440_/Q _5094_/X _4880_/X _5095_/X VGND VGND VPWR VPWR _8440_/D sky130_fd_sc_hd__a22o_1
X_8926_ _8926_/CLK _8926_/D VGND VGND VPWR VPWR _8926_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_84_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4049_ _4626_/A VGND VGND VPWR VPWR _4049_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_83_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8857_ _8951_/CLK _8857_/D VGND VGND VPWR VPWR _8857_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_25_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8788_ _9044_/CLK _8788_/D VGND VGND VPWR VPWR _8788_/Q sky130_fd_sc_hd__dfxtp_1
X_7808_ _8277_/Q _8245_/Q _8213_/Q _9013_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7808_/X sky130_fd_sc_hd__mux4_2
XFILLER_33_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7739_ _8114_/Q _8082_/Q _8050_/Q _9042_/Q _7798_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7739_/X sky130_fd_sc_hd__mux4_1
XFILLER_20_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_133_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_2071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_2082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6070_ _6994_/X _5900_/B _6060_/X _6069_/X VGND VGND VPWR VPWR _6070_/X sky130_fd_sc_hd__o22a_1
X_5021_ _8491_/Q _5019_/X _4911_/X _5020_/X VGND VGND VPWR VPWR _8491_/D sky130_fd_sc_hd__a22o_1
XFILLER_78_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater225 _7615_/S1 VGND VGND VPWR VPWR _7657_/S1 sky130_fd_sc_hd__buf_8
Xrepeater203 _6961_/S VGND VGND VPWR VPWR _6971_/S sky130_fd_sc_hd__buf_6
Xrepeater214 _8001_/S1 VGND VGND VPWR VPWR _8031_/S1 sky130_fd_sc_hd__buf_6
Xrepeater247 _7599_/S0 VGND VGND VPWR VPWR _7594_/S0 sky130_fd_sc_hd__buf_8
Xrepeater269 input11/X VGND VGND VPWR VPWR _6097_/A sky130_fd_sc_hd__buf_8
XFILLER_54_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater236 _7897_/S1 VGND VGND VPWR VPWR _7895_/S1 sky130_fd_sc_hd__buf_8
Xrepeater258 _7894_/S0 VGND VGND VPWR VPWR _7875_/S0 sky130_fd_sc_hd__buf_8
XFILLER_38_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8711_ _8873_/CLK _8711_/D VGND VGND VPWR VPWR _8711_/Q sky130_fd_sc_hd__dfxtp_1
X_6972_ _6991_/X _6994_/X _6974_/S VGND VGND VPWR VPWR _6972_/X sky130_fd_sc_hd__mux2_1
XFILLER_0_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5923_ _5808_/Y _5802_/A _5832_/D _5832_/B VGND VGND VPWR VPWR _5924_/A sky130_fd_sc_hd__o22a_1
X_8642_ _8709_/CLK _8642_/D VGND VGND VPWR VPWR _8642_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_110_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5854_ _6991_/X VGND VGND VPWR VPWR _5908_/A sky130_fd_sc_hd__inv_2
X_4805_ _8612_/Q _4801_/X _4655_/X _4802_/X VGND VGND VPWR VPWR _8612_/D sky130_fd_sc_hd__a22o_1
X_8573_ _8669_/CLK _8573_/D VGND VGND VPWR VPWR _8573_/Q sky130_fd_sc_hd__dfxtp_1
X_7524_ _8519_/Q _8903_/Q _8839_/Q _8871_/Q _7604_/S0 _7604_/S1 VGND VGND VPWR VPWR
+ _7524_/X sky130_fd_sc_hd__mux4_1
X_5785_ _5785_/A VGND VGND VPWR VPWR _5890_/B sky130_fd_sc_hd__inv_2
XFILLER_21_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4736_ _8659_/Q _4732_/X _4619_/X _4733_/X VGND VGND VPWR VPWR _8659_/D sky130_fd_sc_hd__a22o_1
XFILLER_135_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7455_ _8708_/Q _8676_/Q _8644_/Q _8612_/Q _7579_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7455_/X sky130_fd_sc_hd__mux4_1
X_4667_ _4684_/A VGND VGND VPWR VPWR _4667_/X sky130_fd_sc_hd__clkbuf_2
X_7386_ _7382_/X _7383_/X _7384_/X _7385_/X _6343_/C _6343_/B VGND VGND VPWR VPWR
+ _7386_/X sky130_fd_sc_hd__mux4_1
X_6406_ _5953_/Y _6278_/A _6297_/C _6297_/B VGND VGND VPWR VPWR _6406_/X sky130_fd_sc_hd__o22a_1
X_4598_ _8732_/Q _4588_/X _4597_/X _4591_/X VGND VGND VPWR VPWR _8732_/D sky130_fd_sc_hd__a22o_1
XFILLER_103_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6337_ _6182_/Y _6186_/Y _6336_/X _6181_/X _6185_/X VGND VGND VPWR VPWR _6337_/X
+ sky130_fd_sc_hd__o311a_1
XFILLER_88_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6268_ _6971_/S _6268_/B VGND VGND VPWR VPWR _6268_/Y sky130_fd_sc_hd__nor2_1
X_9056_ _9056_/CLK _9056_/D repeater146/X VGND VGND VPWR VPWR _9056_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_76_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5219_ _8381_/Q _5212_/X _5140_/X _5216_/X VGND VGND VPWR VPWR _8381_/D sky130_fd_sc_hd__a22o_1
X_8007_ _8607_/Q _8159_/Q _8511_/Q _8799_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _8007_/X sky130_fd_sc_hd__mux4_1
XFILLER_76_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6199_ _6201_/A _6199_/B VGND VGND VPWR VPWR _6199_/X sky130_fd_sc_hd__or2_2
XFILLER_28_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8909_ _8941_/CLK _8909_/D VGND VGND VPWR VPWR _8909_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_12_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_4_0_0_clk clkbuf_4_1_0_clk/A VGND VGND VPWR VPWR clkbuf_4_0_0_clk/X sky130_fd_sc_hd__clkbuf_1
XFILLER_4_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_122_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5570_ _5570_/A VGND VGND VPWR VPWR _5570_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4521_ _4528_/A VGND VGND VPWR VPWR _4521_/X sky130_fd_sc_hd__buf_2
XFILLER_8_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4452_ _4459_/A VGND VGND VPWR VPWR _4452_/X sky130_fd_sc_hd__clkbuf_2
X_7240_ _8976_/Q _8400_/Q _8176_/Q _8752_/Q _7240_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7240_/X sky130_fd_sc_hd__mux4_1
X_7171_ _7167_/X _7168_/X _7169_/X _7170_/X _7191_/S0 _7191_/S1 VGND VGND VPWR VPWR
+ _7171_/X sky130_fd_sc_hd__mux4_1
XFILLER_113_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4383_ _8867_/Q _4374_/X _4382_/X _4376_/X VGND VGND VPWR VPWR _8867_/D sky130_fd_sc_hd__a22o_1
XFILLER_124_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6122_ _6105_/X _7067_/X VGND VGND VPWR VPWR _6122_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_105_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6053_ _5870_/A _5776_/A _7006_/X _6101_/B _6052_/X VGND VGND VPWR VPWR _6056_/A
+ sky130_fd_sc_hd__o221a_1
XFILLER_58_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5004_ _8502_/Q _4998_/X _4884_/X _4999_/X VGND VGND VPWR VPWR _8502_/D sky130_fd_sc_hd__a22o_1
XFILLER_39_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6955_ _7051_/X _7054_/X _6963_/S VGND VGND VPWR VPWR _6955_/X sky130_fd_sc_hd__mux2_1
XFILLER_54_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5906_ _5918_/A _5906_/B VGND VGND VPWR VPWR _6433_/B sky130_fd_sc_hd__or2_1
XFILLER_53_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6886_ _6885_/X _6887_/X _6948_/S VGND VGND VPWR VPWR _6886_/X sky130_fd_sc_hd__mux2_1
X_8625_ _8725_/CLK _8625_/D VGND VGND VPWR VPWR _8625_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5837_ _5837_/A VGND VGND VPWR VPWR _5837_/Y sky130_fd_sc_hd__inv_2
XFILLER_10_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5768_ _8034_/Q _5762_/X _4659_/A _5763_/X VGND VGND VPWR VPWR _8034_/D sky130_fd_sc_hd__a22o_1
X_8556_ _8940_/CLK _8556_/D VGND VGND VPWR VPWR _8556_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_10_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4719_ _4733_/A VGND VGND VPWR VPWR _4719_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_108_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8487_ _8939_/CLK _8487_/D VGND VGND VPWR VPWR _8487_/Q sky130_fd_sc_hd__dfxtp_1
X_7507_ _8582_/Q _8134_/Q _8486_/Q _8774_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7507_/X sky130_fd_sc_hd__mux4_1
XFILLER_5_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7438_ _8259_/Q _8227_/Q _8195_/Q _8995_/Q _7500_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7438_/X sky130_fd_sc_hd__mux4_1
X_5699_ _8081_/Q _5693_/X _4623_/A _5694_/X VGND VGND VPWR VPWR _8081_/D sky130_fd_sc_hd__a22o_1
X_7369_ _8125_/Q _8093_/Q _8061_/Q _9053_/Q _7369_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7369_/X sky130_fd_sc_hd__mux4_2
XFILLER_115_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9039_ _9067_/CLK _9039_/D VGND VGND VPWR VPWR _9039_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_76_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_110_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6740_ _7366_/X _7371_/X _6744_/S VGND VGND VPWR VPWR _6740_/X sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_109_clk clkbuf_4_2_0_clk/X VGND VGND VPWR VPWR _8951_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6671_ _6521_/Y _6041_/X _6523_/B _6661_/X VGND VGND VPWR VPWR _6671_/X sky130_fd_sc_hd__o22a_1
XFILLER_31_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5622_ _8132_/Q _5618_/X _5472_/X _5619_/X VGND VGND VPWR VPWR _8132_/D sky130_fd_sc_hd__a22o_1
X_8410_ _8922_/CLK _8410_/D VGND VGND VPWR VPWR _8410_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_3_7_0_clk clkbuf_3_7_0_clk/A VGND VGND VPWR VPWR clkbuf_3_7_0_clk/X sky130_fd_sc_hd__clkbuf_1
X_8341_ _8821_/CLK _8341_/D VGND VGND VPWR VPWR _8341_/Q sky130_fd_sc_hd__dfxtp_1
X_5553_ _8179_/Q _5549_/X _5436_/X _5550_/X VGND VGND VPWR VPWR _8179_/D sky130_fd_sc_hd__a22o_1
XFILLER_129_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4504_ _8792_/Q _4500_/X _4332_/X _4501_/X VGND VGND VPWR VPWR _8792_/D sky130_fd_sc_hd__a22o_1
X_5484_ _5501_/A VGND VGND VPWR VPWR _5484_/X sky130_fd_sc_hd__clkbuf_2
X_8272_ _8975_/CLK _8272_/D VGND VGND VPWR VPWR _8272_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_132_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4435_ _8835_/Q _4430_/X _4382_/X _4431_/X VGND VGND VPWR VPWR _8835_/D sky130_fd_sc_hd__a22o_1
X_7223_ _8431_/Q _8303_/Q _8367_/Q _8559_/Q _7240_/S0 input34/X VGND VGND VPWR VPWR
+ _7223_/X sky130_fd_sc_hd__mux4_1
X_4366_ _4641_/A VGND VGND VPWR VPWR _4366_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_116_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7154_ _8520_/Q _8904_/Q _8840_/Q _8872_/Q _7374_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7154_/X sky130_fd_sc_hd__mux4_1
X_6105_ _6105_/A VGND VGND VPWR VPWR _6105_/X sky130_fd_sc_hd__buf_1
X_4297_ _8907_/Q _4295_/X _4066_/X _4296_/X VGND VGND VPWR VPWR _8907_/D sky130_fd_sc_hd__a22o_1
X_7085_ _8705_/Q _8673_/Q _8641_/Q _8609_/Q _7374_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7085_/X sky130_fd_sc_hd__mux4_2
XFILLER_132_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_100_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6036_ _7012_/X VGND VGND VPWR VPWR _6673_/A sky130_fd_sc_hd__inv_2
XFILLER_73_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7987_ _8606_/Q _8158_/Q _8510_/Q _8798_/Q _7990_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7987_/X sky130_fd_sc_hd__mux4_1
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6938_ _7000_/X _7003_/X _6974_/S VGND VGND VPWR VPWR _6938_/X sky130_fd_sc_hd__mux2_1
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6869_ _6939_/X _6936_/X _6932_/S VGND VGND VPWR VPWR _6869_/X sky130_fd_sc_hd__mux2_1
XPHY_1958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8608_ _9054_/CLK _8608_/D VGND VGND VPWR VPWR _8608_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_1969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8539_ _8956_/CLK _8539_/D VGND VGND VPWR VPWR _8539_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_41_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_136_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_99_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4220_ _8957_/Q _4214_/X _4006_/X _4217_/X VGND VGND VPWR VPWR _8957_/D sky130_fd_sc_hd__a22o_1
XFILLER_122_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4151_ _8997_/Q _4148_/X _4087_/X _4149_/X VGND VGND VPWR VPWR _8997_/D sky130_fd_sc_hd__a22o_1
XFILLER_95_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4082_ _6784_/X VGND VGND VPWR VPWR _4650_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_95_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8890_ _8922_/CLK _8890_/D VGND VGND VPWR VPWR _8890_/Q sky130_fd_sc_hd__dfxtp_1
X_7910_ _8986_/Q _8410_/Q _8186_/Q _8762_/Q _7910_/S0 _7910_/S1 VGND VGND VPWR VPWR
+ _7910_/X sky130_fd_sc_hd__mux4_1
XFILLER_64_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7841_ _7837_/X _7838_/X _7839_/X _7840_/X _7901_/S0 _8031_/S1 VGND VGND VPWR VPWR
+ _7841_/X sky130_fd_sc_hd__mux4_2
XFILLER_91_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4984_ _8514_/Q _4978_/X _4932_/X _4979_/X VGND VGND VPWR VPWR _8514_/D sky130_fd_sc_hd__a22o_1
X_7772_ _8820_/Q _8340_/Q _8948_/Q _8468_/Q _7919_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7772_/X sky130_fd_sc_hd__mux4_1
XFILLER_51_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6723_ _6722_/X _9076_/Q _6733_/S VGND VGND VPWR VPWR _6723_/X sky130_fd_sc_hd__mux2_1
X_6654_ _6949_/X _6620_/A _7069_/X _6572_/A _6653_/Y VGND VGND VPWR VPWR _6654_/Y
+ sky130_fd_sc_hd__o221ai_4
X_5605_ _5619_/A VGND VGND VPWR VPWR _5605_/X sky130_fd_sc_hd__clkbuf_2
X_6585_ _6621_/A VGND VGND VPWR VPWR _6585_/X sky130_fd_sc_hd__buf_1
XFILLER_127_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8324_ _9034_/CLK _8324_/D VGND VGND VPWR VPWR _8324_/Q sky130_fd_sc_hd__dfxtp_1
X_5536_ _5550_/A VGND VGND VPWR VPWR _5536_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_132_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8255_ _9020_/CLK _8255_/D VGND VGND VPWR VPWR _8255_/Q sky130_fd_sc_hd__dfxtp_1
X_5467_ _6784_/X VGND VGND VPWR VPWR _5467_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_87_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7206_ _7202_/X _7203_/X _7204_/X _7205_/X _7241_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7206_/X sky130_fd_sc_hd__mux4_1
X_4418_ _8848_/Q _4416_/X _4351_/X _4417_/X VGND VGND VPWR VPWR _8848_/D sky130_fd_sc_hd__a22o_1
XFILLER_120_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5398_ _8260_/Q _5394_/X _5200_/X _5395_/X VGND VGND VPWR VPWR _8260_/D sky130_fd_sc_hd__a22o_1
X_8186_ _9078_/CLK _8186_/D VGND VGND VPWR VPWR _8186_/Q sky130_fd_sc_hd__dfxtp_1
X_7137_ _8582_/Q _8134_/Q _8486_/Q _8774_/Q _7140_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7137_/X sky130_fd_sc_hd__mux4_2
XFILLER_59_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4349_ _8881_/Q _4338_/X _4348_/X _4340_/X VGND VGND VPWR VPWR _8881_/D sky130_fd_sc_hd__a22o_1
XFILLER_100_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7068_ _6086_/B _5844_/X _7068_/S VGND VGND VPWR VPWR _7068_/X sky130_fd_sc_hd__mux2_1
XFILLER_59_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6019_ _6011_/X _6016_/Y _6018_/X VGND VGND VPWR VPWR _6019_/X sky130_fd_sc_hd__o21a_1
XFILLER_46_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_40_clk clkbuf_4_6_0_clk/X VGND VGND VPWR VPWR _8929_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_13_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6370_ _6205_/A _6205_/B _6358_/X _6314_/X VGND VGND VPWR VPWR _6370_/X sky130_fd_sc_hd__o31a_1
XFILLER_114_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5321_ _8313_/Q _5318_/X _5150_/X _5319_/X VGND VGND VPWR VPWR _8313_/D sky130_fd_sc_hd__a22o_1
XFILLER_114_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8040_ _9035_/CLK _8040_/D VGND VGND VPWR VPWR _8040_/Q sky130_fd_sc_hd__dfxtp_1
X_5252_ _8358_/Q _5250_/X _5195_/X _5251_/X VGND VGND VPWR VPWR _8358_/D sky130_fd_sc_hd__a22o_1
X_5183_ _6789_/X VGND VGND VPWR VPWR _5183_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_102_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4203_ _8964_/Q _4199_/X _4091_/X _4200_/X VGND VGND VPWR VPWR _8964_/D sky130_fd_sc_hd__a22o_1
XFILLER_96_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4134_ _4148_/A VGND VGND VPWR VPWR _4134_/X sky130_fd_sc_hd__buf_2
XFILLER_3_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4065_ _6789_/X VGND VGND VPWR VPWR _4638_/A sky130_fd_sc_hd__clkbuf_2
X_8942_ _8942_/CLK _8942_/D VGND VGND VPWR VPWR _8942_/Q sky130_fd_sc_hd__dfxtp_1
X_8873_ _8873_/CLK _8873_/D VGND VGND VPWR VPWR _8873_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_83_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7824_ _8534_/Q _8918_/Q _8854_/Q _8886_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7824_/X sky130_fd_sc_hd__mux4_1
XFILLER_12_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7755_ _8723_/Q _8691_/Q _8659_/Q _8627_/Q _7919_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7755_/X sky130_fd_sc_hd__mux4_2
XPHY_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4967_ _8527_/Q _4964_/X _4902_/X _4965_/X VGND VGND VPWR VPWR _8527_/D sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_31_clk clkbuf_4_7_0_clk/X VGND VGND VPWR VPWR _8841_/CLK sky130_fd_sc_hd__clkbuf_16
X_4898_ _4922_/A VGND VGND VPWR VPWR _4898_/X sky130_fd_sc_hd__buf_2
X_6706_ _7196_/X _7201_/X _6714_/S VGND VGND VPWR VPWR _6706_/X sky130_fd_sc_hd__mux2_1
XFILLER_20_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7686_ _7682_/X _7683_/X _7684_/X _7685_/X _7711_/S0 input11/X VGND VGND VPWR VPWR
+ _7686_/X sky130_fd_sc_hd__mux4_2
X_6637_ _6637_/A VGND VGND VPWR VPWR _6637_/Y sky130_fd_sc_hd__inv_2
X_6568_ _6437_/A _6466_/Y _6467_/X VGND VGND VPWR VPWR _6568_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_4_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5519_ _8201_/Q _5515_/X _5460_/X _5516_/X VGND VGND VPWR VPWR _8201_/D sky130_fd_sc_hd__a22o_1
X_8307_ _8786_/CLK _8307_/D VGND VGND VPWR VPWR _8307_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_106_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6499_ _6498_/Y _6010_/A _6830_/X _6010_/Y VGND VGND VPWR VPWR _6500_/A sky130_fd_sc_hd__o22a_1
XFILLER_105_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8238_ _9067_/CLK _8238_/D VGND VGND VPWR VPWR _8238_/Q sky130_fd_sc_hd__dfxtp_1
X_8169_ _8970_/CLK _8169_/D VGND VGND VPWR VPWR _8169_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_99_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_98_clk clkbuf_4_8_0_clk/X VGND VGND VPWR VPWR _9048_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_59_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_2220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_22_clk clkbuf_4_4_0_clk/X VGND VGND VPWR VPWR _8991_/CLK sky130_fd_sc_hd__clkbuf_16
XPHY_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_78_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5870_ _5870_/A _6101_/A _5870_/C _5870_/D VGND VGND VPWR VPWR _6452_/C sky130_fd_sc_hd__or4_4
XFILLER_18_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4821_ _4828_/A VGND VGND VPWR VPWR _4821_/X sky130_fd_sc_hd__clkbuf_2
X_4752_ _8647_/Q _4746_/X _4647_/X _4747_/X VGND VGND VPWR VPWR _8647_/D sky130_fd_sc_hd__a22o_1
X_7540_ _8968_/Q _8392_/Q _8168_/Q _8744_/Q _7594_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7540_/X sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_13_clk _8032_/CLK VGND VGND VPWR VPWR _8960_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_14_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7471_ _7467_/X _7468_/X _7469_/X _7470_/X _6098_/A _6097_/A VGND VGND VPWR VPWR
+ _7471_/X sky130_fd_sc_hd__mux4_1
X_4683_ _8694_/Q _4677_/X _4611_/X _4678_/X VGND VGND VPWR VPWR _8694_/D sky130_fd_sc_hd__a22o_1
X_6422_ _6422_/A _6422_/B _6422_/C _6422_/D VGND VGND VPWR VPWR _6428_/A sky130_fd_sc_hd__or4_1
X_6353_ _6333_/D _6352_/X _6333_/D _6352_/X VGND VGND VPWR VPWR _6353_/Y sky130_fd_sc_hd__a2bb2oi_1
X_5304_ _8322_/Q _5298_/X _5204_/X _5299_/X VGND VGND VPWR VPWR _8322_/D sky130_fd_sc_hd__a22o_1
X_6284_ _6284_/A _6284_/B VGND VGND VPWR VPWR _6416_/B sky130_fd_sc_hd__nor2_2
X_9072_ _9086_/CLK _9072_/D repeater147/X VGND VGND VPWR VPWR _9072_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_88_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8023_ _8416_/Q _8288_/Q _8352_/Q _8544_/Q _8025_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _8023_/X sky130_fd_sc_hd__mux4_1
X_5235_ _8369_/Q _5229_/X _5168_/X _5230_/X VGND VGND VPWR VPWR _8369_/D sky130_fd_sc_hd__a22o_1
XFILLER_130_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5166_ _6796_/X VGND VGND VPWR VPWR _5166_/X sky130_fd_sc_hd__clkbuf_2
X_4117_ _9021_/Q _4109_/X _4006_/X _4114_/X VGND VGND VPWR VPWR _9021_/D sky130_fd_sc_hd__a22o_1
X_5097_ _8441_/Q _5094_/X _4878_/X _5095_/X VGND VGND VPWR VPWR _8441_/D sky130_fd_sc_hd__a22o_1
XFILLER_29_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8925_ _8958_/CLK _8925_/D VGND VGND VPWR VPWR _8925_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_56_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4048_ _6794_/X VGND VGND VPWR VPWR _4626_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_17_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8856_ _8950_/CLK _8856_/D VGND VGND VPWR VPWR _8856_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8787_ _8787_/CLK _8787_/D VGND VGND VPWR VPWR _8787_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_25_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5999_ _5999_/A VGND VGND VPWR VPWR _5999_/X sky130_fd_sc_hd__clkbuf_2
X_7807_ _8597_/Q _8149_/Q _8501_/Q _8789_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7807_/X sky130_fd_sc_hd__mux4_2
XFILLER_40_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7738_ _8274_/Q _8242_/Q _8210_/Q _9010_/Q _7798_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7738_/X sky130_fd_sc_hd__mux4_2
XFILLER_138_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7669_ _8110_/Q _8078_/Q _8046_/Q _9038_/Q _7689_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7669_/X sky130_fd_sc_hd__mux4_1
XFILLER_109_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_2050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5020_ _5027_/A VGND VGND VPWR VPWR _5020_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_2_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xrepeater226 _7579_/S1 VGND VGND VPWR VPWR _7615_/S1 sky130_fd_sc_hd__buf_6
XFILLER_66_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater204 _6939_/S VGND VGND VPWR VPWR _6961_/S sky130_fd_sc_hd__buf_4
XFILLER_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_2_clk clkbuf_4_0_0_clk/X VGND VGND VPWR VPWR _9013_/CLK sky130_fd_sc_hd__clkbuf_16
Xrepeater215 input17/X VGND VGND VPWR VPWR _8001_/S1 sky130_fd_sc_hd__buf_8
XFILLER_120_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrepeater248 _7599_/S0 VGND VGND VPWR VPWR _7600_/S0 sky130_fd_sc_hd__buf_4
XFILLER_66_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater259 _7894_/S0 VGND VGND VPWR VPWR _7900_/S0 sky130_fd_sc_hd__buf_6
Xrepeater237 _7900_/S1 VGND VGND VPWR VPWR _7897_/S1 sky130_fd_sc_hd__buf_6
XFILLER_93_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8710_ _8710_/CLK _8710_/D VGND VGND VPWR VPWR _8710_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_93_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6971_ _6973_/X _6972_/X _6971_/S VGND VGND VPWR VPWR _6971_/X sky130_fd_sc_hd__mux2_1
XFILLER_19_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5922_ _5914_/A _5862_/B _5863_/B VGND VGND VPWR VPWR _5922_/X sky130_fd_sc_hd__a21bo_1
XFILLER_80_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8641_ _9056_/CLK _8641_/D VGND VGND VPWR VPWR _8641_/Q sky130_fd_sc_hd__dfxtp_1
X_5853_ _6994_/X VGND VGND VPWR VPWR _5900_/A sky130_fd_sc_hd__inv_2
XFILLER_21_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4804_ _8613_/Q _4801_/X _4653_/X _4802_/X VGND VGND VPWR VPWR _8613_/D sky130_fd_sc_hd__a22o_1
X_8572_ _8731_/CLK _8572_/D VGND VGND VPWR VPWR _8572_/Q sky130_fd_sc_hd__dfxtp_1
X_5784_ _6996_/X _6043_/B VGND VGND VPWR VPWR _5785_/A sky130_fd_sc_hd__nand2_2
XFILLER_21_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7523_ _8423_/Q _8295_/Q _8359_/Q _8551_/Q _7604_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7523_/X sky130_fd_sc_hd__mux4_2
X_4735_ _8660_/Q _4732_/X _4617_/X _4733_/X VGND VGND VPWR VPWR _8660_/D sky130_fd_sc_hd__a22o_1
XFILLER_9_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7454_ _8516_/Q _8900_/Q _8836_/Q _8868_/Q _7579_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7454_/X sky130_fd_sc_hd__mux4_2
X_4666_ _4705_/A VGND VGND VPWR VPWR _4684_/A sky130_fd_sc_hd__clkbuf_4
X_7385_ _8735_/Q _8703_/Q _8671_/Q _8639_/Q _6343_/A _6344_/B VGND VGND VPWR VPWR
+ _7385_/X sky130_fd_sc_hd__mux4_1
X_4597_ _4597_/A VGND VGND VPWR VPWR _4597_/X sky130_fd_sc_hd__buf_2
X_6405_ _6368_/X _7043_/X VGND VGND VPWR VPWR _6405_/Y sky130_fd_sc_hd__nand2b_1
X_6336_ _6114_/X _6331_/A _6318_/X _6333_/X _6335_/X VGND VGND VPWR VPWR _6336_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_135_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_9055_ _9055_/CLK _9055_/D VGND VGND VPWR VPWR _9055_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6267_ _6267_/A VGND VGND VPWR VPWR _6268_/B sky130_fd_sc_hd__inv_2
X_8006_ _8002_/X _8003_/X _8004_/X _8005_/X _8006_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _8006_/X sky130_fd_sc_hd__mux4_2
X_5218_ _8382_/Q _5212_/X _5138_/X _5216_/X VGND VGND VPWR VPWR _8382_/D sky130_fd_sc_hd__a22o_1
X_6198_ _6199_/B VGND VGND VPWR VPWR _6198_/Y sky130_fd_sc_hd__inv_2
XFILLER_57_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5149_ _8410_/Q _5146_/X _5147_/X _5148_/X VGND VGND VPWR VPWR _8410_/D sky130_fd_sc_hd__a22o_1
XFILLER_84_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8908_ _8940_/CLK _8908_/D VGND VGND VPWR VPWR _8908_/Q sky130_fd_sc_hd__dfxtp_1
X_8839_ _9056_/CLK _8839_/D VGND VGND VPWR VPWR _8839_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_138_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_95_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4520_ _8780_/Q _4514_/X _4360_/X _4515_/X VGND VGND VPWR VPWR _8780_/D sky130_fd_sc_hd__a22o_1
XPHY_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4451_ _4458_/A VGND VGND VPWR VPWR _4451_/X sky130_fd_sc_hd__clkbuf_2
X_7170_ _8969_/Q _8393_/Q _8169_/Q _8745_/Q _7190_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7170_/X sky130_fd_sc_hd__mux4_1
XFILLER_116_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4382_ _4657_/A VGND VGND VPWR VPWR _4382_/X sky130_fd_sc_hd__clkbuf_2
X_6121_ _6121_/A VGND VGND VPWR VPWR _6121_/X sky130_fd_sc_hd__buf_1
XFILLER_124_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6052_ _6101_/A _6044_/A _6673_/A _6518_/A VGND VGND VPWR VPWR _6052_/X sky130_fd_sc_hd__o22a_1
XFILLER_100_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5003_ _8503_/Q _4998_/X _4882_/X _4999_/X VGND VGND VPWR VPWR _8503_/D sky130_fd_sc_hd__a22o_1
XFILLER_81_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6954_ _6956_/X _6955_/X _6961_/S VGND VGND VPWR VPWR _6954_/X sky130_fd_sc_hd__mux2_1
X_5905_ _6961_/S _6952_/X VGND VGND VPWR VPWR _5906_/B sky130_fd_sc_hd__or2_1
X_6885_ _6884_/X _6893_/X _6918_/S VGND VGND VPWR VPWR _6885_/X sky130_fd_sc_hd__mux2_1
XFILLER_14_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8624_ _8911_/CLK _8624_/D VGND VGND VPWR VPWR _8624_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_139_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5836_ _6513_/A _6513_/B _5886_/A _5835_/Y VGND VGND VPWR VPWR _5837_/A sky130_fd_sc_hd__o31a_1
XFILLER_22_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8555_ _8841_/CLK _8555_/D VGND VGND VPWR VPWR _8555_/Q sky130_fd_sc_hd__dfxtp_1
X_5767_ _8035_/Q _5762_/X _4657_/A _5763_/X VGND VGND VPWR VPWR _8035_/D sky130_fd_sc_hd__a22o_1
X_7506_ _7502_/X _7503_/X _7504_/X _7505_/X _7611_/S0 _7611_/S1 VGND VGND VPWR VPWR
+ _7506_/X sky130_fd_sc_hd__mux4_2
X_8486_ _8966_/CLK _8486_/D VGND VGND VPWR VPWR _8486_/Q sky130_fd_sc_hd__dfxtp_1
X_4718_ _4754_/A VGND VGND VPWR VPWR _4733_/A sky130_fd_sc_hd__clkbuf_4
X_5698_ _8082_/Q _5693_/X _4621_/A _5694_/X VGND VGND VPWR VPWR _8082_/D sky130_fd_sc_hd__a22o_1
XFILLER_135_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4649_ _4649_/A VGND VGND VPWR VPWR _4649_/X sky130_fd_sc_hd__clkbuf_2
X_7437_ _8579_/Q _8131_/Q _8483_/Q _8771_/Q _7500_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7437_/X sky130_fd_sc_hd__mux4_1
XFILLER_107_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7368_ _8285_/Q _8253_/Q _8221_/Q _9021_/Q _7389_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7368_/X sky130_fd_sc_hd__mux4_1
XFILLER_103_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6319_ _9080_/Q _6159_/B _6160_/A VGND VGND VPWR VPWR _6321_/B sky130_fd_sc_hd__o21ai_1
X_7299_ _8118_/Q _8086_/Q _8054_/Q _9046_/Q _7339_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7299_/X sky130_fd_sc_hd__mux4_1
XFILLER_131_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_131_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9038_ _9038_/CLK _9038_/D VGND VGND VPWR VPWR _9038_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6670_ _6105_/A _7010_/X VGND VGND VPWR VPWR _6670_/Y sky130_fd_sc_hd__nand2b_1
X_5621_ _8133_/Q _5618_/X _5470_/X _5619_/X VGND VGND VPWR VPWR _8133_/D sky130_fd_sc_hd__a22o_1
X_8340_ _9051_/CLK _8340_/D VGND VGND VPWR VPWR _8340_/Q sky130_fd_sc_hd__dfxtp_1
X_5552_ _8180_/Q _5549_/X _5434_/X _5550_/X VGND VGND VPWR VPWR _8180_/D sky130_fd_sc_hd__a22o_1
X_4503_ _8793_/Q _4500_/X _4330_/X _4501_/X VGND VGND VPWR VPWR _8793_/D sky130_fd_sc_hd__a22o_1
X_8271_ _8975_/CLK _8271_/D VGND VGND VPWR VPWR _8271_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5483_ _5522_/A VGND VGND VPWR VPWR _5501_/A sky130_fd_sc_hd__buf_4
X_4434_ _8836_/Q _4430_/X _4380_/X _4431_/X VGND VGND VPWR VPWR _8836_/D sky130_fd_sc_hd__a22o_1
X_7222_ _8815_/Q _8335_/Q _8943_/Q _8463_/Q _7240_/S0 input34/X VGND VGND VPWR VPWR
+ _7222_/X sky130_fd_sc_hd__mux4_1
X_4365_ _8875_/Q _4362_/X _4363_/X _4364_/X VGND VGND VPWR VPWR _8875_/D sky130_fd_sc_hd__a22o_1
X_7153_ _8424_/Q _8296_/Q _8360_/Q _8552_/Q _7374_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7153_/X sky130_fd_sc_hd__mux4_1
XFILLER_113_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7084_ _8513_/Q _8897_/Q _8833_/Q _8865_/Q _7374_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7084_/X sky130_fd_sc_hd__mux4_1
X_6104_ _6677_/A _6452_/C _6103_/Y VGND VGND VPWR VPWR _6104_/X sky130_fd_sc_hd__a21o_1
XFILLER_112_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4296_ _4303_/A VGND VGND VPWR VPWR _4296_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_100_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6035_ _7018_/X _6658_/B _7015_/X _6664_/B VGND VGND VPWR VPWR _6035_/X sky130_fd_sc_hd__a22o_1
XFILLER_132_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7986_ _7982_/X _7983_/X _7984_/X _7985_/X _8006_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _7986_/X sky130_fd_sc_hd__mux4_2
XFILLER_82_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6937_ _7006_/X _7009_/X _6974_/S VGND VGND VPWR VPWR _6937_/X sky130_fd_sc_hd__mux2_1
XFILLER_25_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6868_ _5916_/X _6991_/X _6943_/S VGND VGND VPWR VPWR _6868_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8607_ _8959_/CLK _8607_/D VGND VGND VPWR VPWR _8607_/Q sky130_fd_sc_hd__dfxtp_1
X_5819_ _5819_/A VGND VGND VPWR VPWR _5820_/A sky130_fd_sc_hd__inv_2
XFILLER_50_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8538_ _8922_/CLK _8538_/D VGND VGND VPWR VPWR _8538_/Q sky130_fd_sc_hd__dfxtp_1
X_6799_ _6623_/Y _6631_/Y _6809_/S VGND VGND VPWR VPWR _6799_/X sky130_fd_sc_hd__mux2_4
XFILLER_136_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8469_ _8821_/CLK _8469_/D VGND VGND VPWR VPWR _8469_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_135_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4150_ _8998_/Q _4148_/X _4083_/X _4149_/X VGND VGND VPWR VPWR _8998_/D sky130_fd_sc_hd__a22o_1
Xoutput90 _6737_/X VGND VGND VPWR VPWR regData[27] sky130_fd_sc_hd__clkbuf_2
XFILLER_1_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4081_ _9031_/Q _4068_/X _4080_/X _4071_/X VGND VGND VPWR VPWR _9031_/D sky130_fd_sc_hd__a22o_1
XFILLER_95_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7840_ _8983_/Q _8407_/Q _8183_/Q _8759_/Q _7900_/S0 _7900_/S1 VGND VGND VPWR VPWR
+ _7840_/X sky130_fd_sc_hd__mux4_1
X_4983_ _8515_/Q _4978_/X _4930_/X _4979_/X VGND VGND VPWR VPWR _8515_/D sky130_fd_sc_hd__a22o_1
X_7771_ _7767_/X _7768_/X _7769_/X _7770_/X _7811_/S0 _8021_/S1 VGND VGND VPWR VPWR
+ _7771_/X sky130_fd_sc_hd__mux4_2
X_6722_ _7276_/X _7281_/X _6734_/S VGND VGND VPWR VPWR _6722_/X sky130_fd_sc_hd__mux2_1
X_6653_ _6655_/A _6010_/Y _6621_/A VGND VGND VPWR VPWR _6653_/Y sky130_fd_sc_hd__o21ai_2
XFILLER_32_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5604_ _5618_/A VGND VGND VPWR VPWR _5604_/X sky130_fd_sc_hd__clkbuf_2
X_6584_ _6620_/A VGND VGND VPWR VPWR _6584_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_118_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8323_ _9034_/CLK _8323_/D VGND VGND VPWR VPWR _8323_/Q sky130_fd_sc_hd__dfxtp_1
X_5535_ _5571_/A VGND VGND VPWR VPWR _5550_/A sky130_fd_sc_hd__buf_4
XFILLER_127_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8254_ _9053_/CLK _8254_/D VGND VGND VPWR VPWR _8254_/Q sky130_fd_sc_hd__dfxtp_1
X_5466_ _5466_/A VGND VGND VPWR VPWR _5466_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_132_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4417_ _4431_/A VGND VGND VPWR VPWR _4417_/X sky130_fd_sc_hd__clkbuf_2
X_7205_ _8717_/Q _8685_/Q _8653_/Q _8621_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7205_/X sky130_fd_sc_hd__mux4_1
XFILLER_99_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5397_ _8261_/Q _5394_/X _5198_/X _5395_/X VGND VGND VPWR VPWR _8261_/D sky130_fd_sc_hd__a22o_1
X_8185_ _9078_/CLK _8185_/D VGND VGND VPWR VPWR _8185_/Q sky130_fd_sc_hd__dfxtp_1
X_7136_ _7132_/X _7133_/X _7134_/X _7135_/X input35/X _7191_/S1 VGND VGND VPWR VPWR
+ _7136_/X sky130_fd_sc_hd__mux4_2
XFILLER_99_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4348_ _4623_/A VGND VGND VPWR VPWR _4348_/X sky130_fd_sc_hd__clkbuf_2
X_7067_ _8006_/X _8011_/X _7067_/S VGND VGND VPWR VPWR _7067_/X sky130_fd_sc_hd__mux2_2
X_4279_ _8919_/Q _4274_/X _4026_/X _4275_/X VGND VGND VPWR VPWR _8919_/D sky130_fd_sc_hd__a22o_1
X_6018_ _7030_/X _6002_/X _7027_/X _6017_/Y VGND VGND VPWR VPWR _6018_/X sky130_fd_sc_hd__o22a_1
XFILLER_27_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7969_ _8125_/Q _8093_/Q _8061_/Q _9053_/Q _8015_/S0 _5872_/B VGND VGND VPWR VPWR
+ _7969_/X sky130_fd_sc_hd__mux4_2
XFILLER_55_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_123_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_117_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_6_0_clk clkbuf_3_7_0_clk/A VGND VGND VPWR VPWR clkbuf_3_6_0_clk/X sky130_fd_sc_hd__clkbuf_1
XFILLER_92_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5320_ _8314_/Q _5318_/X _5147_/X _5319_/X VGND VGND VPWR VPWR _8314_/D sky130_fd_sc_hd__a22o_1
X_5251_ _5251_/A VGND VGND VPWR VPWR _5251_/X sky130_fd_sc_hd__buf_2
XFILLER_115_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4202_ _8965_/Q _4199_/X _4087_/X _4200_/X VGND VGND VPWR VPWR _8965_/D sky130_fd_sc_hd__a22o_1
XFILLER_87_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5182_ _5194_/A VGND VGND VPWR VPWR _5182_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_96_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4133_ _9009_/Q _4127_/X _4046_/X _4128_/X VGND VGND VPWR VPWR _9009_/D sky130_fd_sc_hd__a22o_1
XFILLER_96_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4064_ _9036_/Q _4051_/X _4063_/X _4054_/X VGND VGND VPWR VPWR _9036_/D sky130_fd_sc_hd__a22o_1
X_8941_ _8941_/CLK _8941_/D VGND VGND VPWR VPWR _8941_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_3_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8872_ _9056_/CLK _8872_/D VGND VGND VPWR VPWR _8872_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_52_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7823_ _8438_/Q _8310_/Q _8374_/Q _8566_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7823_/X sky130_fd_sc_hd__mux4_1
XFILLER_52_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7754_ _8531_/Q _8915_/Q _8851_/Q _8883_/Q _7798_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7754_/X sky130_fd_sc_hd__mux4_1
X_6705_ _6704_/X _9067_/Q _6705_/S VGND VGND VPWR VPWR _6705_/X sky130_fd_sc_hd__mux2_2
XPHY_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4966_ _8528_/Q _4964_/X _4899_/X _4965_/X VGND VGND VPWR VPWR _8528_/D sky130_fd_sc_hd__a22o_1
XFILLER_22_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7685_ _8719_/Q _8687_/Q _8655_/Q _8623_/Q _7710_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7685_/X sky130_fd_sc_hd__mux4_2
X_4897_ _8561_/Q _4886_/X _4896_/X _4888_/X VGND VGND VPWR VPWR _8561_/D sky130_fd_sc_hd__a22o_1
XFILLER_138_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6636_ _6497_/A _6500_/A _6614_/A _6538_/X VGND VGND VPWR VPWR _6637_/A sky130_fd_sc_hd__a31o_1
X_6567_ _6436_/X _6565_/X _7012_/X _6110_/B _6566_/Y VGND VGND VPWR VPWR _6567_/Y
+ sky130_fd_sc_hd__o221ai_2
X_5518_ _8202_/Q _5515_/X _5458_/X _5516_/X VGND VGND VPWR VPWR _8202_/D sky130_fd_sc_hd__a22o_1
XFILLER_106_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8306_ _9019_/CLK _8306_/D VGND VGND VPWR VPWR _8306_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_4_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6498_ _6830_/X VGND VGND VPWR VPWR _6498_/Y sky130_fd_sc_hd__inv_2
X_8237_ _9064_/CLK _8237_/D VGND VGND VPWR VPWR _8237_/Q sky130_fd_sc_hd__dfxtp_1
X_5449_ _8238_/Q _5442_/X _5448_/X _5444_/X VGND VGND VPWR VPWR _8238_/D sky130_fd_sc_hd__a22o_1
X_8168_ _9061_/CLK _8168_/D VGND VGND VPWR VPWR _8168_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_59_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7119_ _8100_/Q _8068_/Q _8036_/Q _9028_/Q _7140_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7119_/X sky130_fd_sc_hd__mux4_2
XFILLER_101_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8099_ _9062_/CLK _8099_/D VGND VGND VPWR VPWR _8099_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_86_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_2210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_92_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_92_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4820_ _8603_/Q _4812_/X _4599_/X _4815_/X VGND VGND VPWR VPWR _8603_/D sky130_fd_sc_hd__a22o_1
XFILLER_34_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4751_ _8648_/Q _4746_/X _4645_/X _4747_/X VGND VGND VPWR VPWR _8648_/D sky130_fd_sc_hd__a22o_1
X_7470_ _8964_/Q _8388_/Q _8164_/Q _8740_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7470_/X sky130_fd_sc_hd__mux4_1
X_4682_ _8695_/Q _4677_/X _4609_/X _4678_/X VGND VGND VPWR VPWR _8695_/D sky130_fd_sc_hd__a22o_1
X_6421_ _6784_/X _6783_/X _6782_/X _6781_/X VGND VGND VPWR VPWR _6422_/D sky130_fd_sc_hd__or4_4
XFILLER_127_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6352_ _6333_/C _6350_/X _6335_/A VGND VGND VPWR VPWR _6352_/X sky130_fd_sc_hd__o21a_1
X_6283_ _6415_/B VGND VGND VPWR VPWR _6284_/B sky130_fd_sc_hd__inv_2
XFILLER_115_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5303_ _8323_/Q _5298_/X _5202_/X _5299_/X VGND VGND VPWR VPWR _8323_/D sky130_fd_sc_hd__a22o_1
X_9071_ _9075_/CLK _9071_/D repeater147/X VGND VGND VPWR VPWR _9071_/Q sky130_fd_sc_hd__dfrtp_2
X_8022_ _8800_/Q _8320_/Q _8928_/Q _8448_/Q _8025_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _8022_/X sky130_fd_sc_hd__mux4_2
X_5234_ _8370_/Q _5229_/X _5166_/X _5230_/X VGND VGND VPWR VPWR _8370_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5165_ _8403_/Q _5158_/X _5164_/X _5160_/X VGND VGND VPWR VPWR _8403_/D sky130_fd_sc_hd__a22o_1
X_4116_ _9022_/Q _4109_/X _4000_/X _4114_/X VGND VGND VPWR VPWR _9022_/D sky130_fd_sc_hd__a22o_1
XFILLER_111_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5096_ _8442_/Q _5094_/X _4875_/X _5095_/X VGND VGND VPWR VPWR _8442_/D sky130_fd_sc_hd__a22o_1
X_8924_ _8959_/CLK _8924_/D VGND VGND VPWR VPWR _8924_/Q sky130_fd_sc_hd__dfxtp_1
X_4047_ _9041_/Q _4034_/X _4046_/X _4037_/X VGND VGND VPWR VPWR _9041_/D sky130_fd_sc_hd__a22o_1
X_8855_ _8922_/CLK _8855_/D VGND VGND VPWR VPWR _8855_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7806_ _7802_/X _7803_/X _7804_/X _7805_/X _7811_/S0 _8021_/S1 VGND VGND VPWR VPWR
+ _7806_/X sky130_fd_sc_hd__mux4_1
XPHY_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8786_ _8786_/CLK _8786_/D VGND VGND VPWR VPWR _8786_/Q sky130_fd_sc_hd__dfxtp_1
X_5998_ _5998_/A VGND VGND VPWR VPWR _5999_/A sky130_fd_sc_hd__inv_2
X_4949_ _8539_/Q _4940_/X _4872_/X _4944_/X VGND VGND VPWR VPWR _8539_/D sky130_fd_sc_hd__a22o_1
X_7737_ _8594_/Q _8146_/Q _8498_/Q _8786_/Q _7798_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7737_/X sky130_fd_sc_hd__mux4_1
XFILLER_33_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7668_ _8270_/Q _8238_/Q _8206_/Q _9006_/Q _7689_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7668_/X sky130_fd_sc_hd__mux4_2
XFILLER_138_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6619_ _6604_/X _7022_/X VGND VGND VPWR VPWR _6619_/Y sky130_fd_sc_hd__nand2b_1
X_7599_ _8107_/Q _8075_/Q _8043_/Q _9035_/Q _7599_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7599_/X sky130_fd_sc_hd__mux4_1
XFILLER_3_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_2051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrepeater216 _7501_/S0 VGND VGND VPWR VPWR _7701_/S0 sky130_fd_sc_hd__buf_8
Xrepeater205 _6974_/S VGND VGND VPWR VPWR _6963_/S sky130_fd_sc_hd__buf_8
Xrepeater227 _7599_/S1 VGND VGND VPWR VPWR _7579_/S1 sky130_fd_sc_hd__buf_8
Xrepeater249 _7599_/S0 VGND VGND VPWR VPWR _7500_/S0 sky130_fd_sc_hd__buf_6
XFILLER_65_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrepeater238 input15/X VGND VGND VPWR VPWR _7900_/S1 sky130_fd_sc_hd__buf_8
XFILLER_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6970_ _6997_/X _7000_/X _6974_/S VGND VGND VPWR VPWR _6970_/X sky130_fd_sc_hd__mux2_1
X_5921_ _6878_/X _5907_/X _5913_/X _5920_/Y VGND VGND VPWR VPWR _5921_/Y sky130_fd_sc_hd__o22ai_1
XFILLER_81_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8640_ _9054_/CLK _8640_/D VGND VGND VPWR VPWR _8640_/Q sky130_fd_sc_hd__dfxtp_1
X_5852_ _6997_/X VGND VGND VPWR VPWR _5890_/A sky130_fd_sc_hd__inv_2
XFILLER_22_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4803_ _8614_/Q _4801_/X _4650_/X _4802_/X VGND VGND VPWR VPWR _8614_/D sky130_fd_sc_hd__a22o_1
X_8571_ _8731_/CLK _8571_/D VGND VGND VPWR VPWR _8571_/Q sky130_fd_sc_hd__dfxtp_1
X_5783_ _5822_/A VGND VGND VPWR VPWR _6043_/B sky130_fd_sc_hd__buf_2
X_7522_ _8807_/Q _8327_/Q _8935_/Q _8455_/Q _7604_/S0 _7604_/S1 VGND VGND VPWR VPWR
+ _7522_/X sky130_fd_sc_hd__mux4_1
X_4734_ _8661_/Q _4732_/X _4614_/X _4733_/X VGND VGND VPWR VPWR _8661_/D sky130_fd_sc_hd__a22o_1
XFILLER_119_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7453_ _8420_/Q _8292_/Q _8356_/Q _8548_/Q _7579_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7453_/X sky130_fd_sc_hd__mux4_1
X_4665_ _5579_/A _4762_/B VGND VGND VPWR VPWR _4705_/A sky130_fd_sc_hd__or2_4
XFILLER_135_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4596_ _8733_/Q _4588_/X _4595_/X _4591_/X VGND VGND VPWR VPWR _8733_/D sky130_fd_sc_hd__a22o_1
X_7384_ _8543_/Q _8927_/Q _8863_/Q _8895_/Q _7390_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7384_/X sky130_fd_sc_hd__mux4_2
X_6404_ _6269_/Y _6403_/Y _6269_/Y _6403_/Y VGND VGND VPWR VPWR _6404_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_115_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6335_ _6335_/A _6335_/B VGND VGND VPWR VPWR _6335_/X sky130_fd_sc_hd__and2_1
XFILLER_135_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_131_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9054_ _9054_/CLK _9054_/D VGND VGND VPWR VPWR _9054_/Q sky130_fd_sc_hd__dfxtp_1
X_8005_ _8735_/Q _8703_/Q _8671_/Q _8639_/Q _8005_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _8005_/X sky130_fd_sc_hd__mux4_1
X_6266_ _6139_/A _6265_/X _6255_/B VGND VGND VPWR VPWR _6267_/A sky130_fd_sc_hd__a21bo_1
XFILLER_88_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5217_ _8383_/Q _5212_/X _5213_/X _5216_/X VGND VGND VPWR VPWR _8383_/D sky130_fd_sc_hd__a22o_1
XFILLER_103_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6197_ _9074_/Q _6151_/B _6152_/A VGND VGND VPWR VPWR _6199_/B sky130_fd_sc_hd__o21ai_1
XFILLER_130_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5148_ _5160_/A VGND VGND VPWR VPWR _5148_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_29_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5079_ _8451_/Q _5074_/X _4930_/X _5075_/X VGND VGND VPWR VPWR _8451_/D sky130_fd_sc_hd__a22o_1
XFILLER_84_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8907_ _8907_/CLK _8907_/D VGND VGND VPWR VPWR _8907_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_84_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8838_ _8934_/CLK _8838_/D VGND VGND VPWR VPWR _8838_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_100_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8769_ _8926_/CLK _8769_/D VGND VGND VPWR VPWR _8769_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_125_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4450_ _8827_/Q _4442_/X _4324_/X _4445_/X VGND VGND VPWR VPWR _8827_/D sky130_fd_sc_hd__a22o_1
XFILLER_7_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4381_ _8868_/Q _4374_/X _4380_/X _4376_/X VGND VGND VPWR VPWR _8868_/D sky130_fd_sc_hd__a22o_1
X_6120_ _6433_/A _6888_/X VGND VGND VPWR VPWR _6121_/A sky130_fd_sc_hd__or2_1
X_6051_ _7015_/X _6664_/B _6050_/Y VGND VGND VPWR VPWR _6051_/X sky130_fd_sc_hd__o21a_1
XFILLER_58_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5002_ _8504_/Q _4998_/X _4880_/X _4999_/X VGND VGND VPWR VPWR _8504_/D sky130_fd_sc_hd__a22o_1
XFILLER_39_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6953_ _7057_/X _7060_/X _6963_/S VGND VGND VPWR VPWR _6953_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5904_ _5797_/B _5893_/X _5797_/B _5893_/X VGND VGND VPWR VPWR _5904_/Y sky130_fd_sc_hd__a2bb2oi_1
X_6884_ _6883_/X _6896_/X _6932_/S VGND VGND VPWR VPWR _6884_/X sky130_fd_sc_hd__mux2_1
X_5835_ _6851_/X _5780_/A _5834_/X VGND VGND VPWR VPWR _5835_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_50_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8623_ _8911_/CLK _8623_/D VGND VGND VPWR VPWR _8623_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_14_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8554_ _8669_/CLK _8554_/D VGND VGND VPWR VPWR _8554_/Q sky130_fd_sc_hd__dfxtp_1
X_5766_ _8036_/Q _5762_/X _4655_/A _5763_/X VGND VGND VPWR VPWR _8036_/D sky130_fd_sc_hd__a22o_1
X_7505_ _8710_/Q _8678_/Q _8646_/Q _8614_/Q _7505_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7505_/X sky130_fd_sc_hd__mux4_2
X_4717_ _4753_/A VGND VGND VPWR VPWR _4754_/A sky130_fd_sc_hd__clkinv_4
X_8485_ _8934_/CLK _8485_/D VGND VGND VPWR VPWR _8485_/Q sky130_fd_sc_hd__dfxtp_1
X_5697_ _8083_/Q _5693_/X _4619_/A _5694_/X VGND VGND VPWR VPWR _8083_/D sky130_fd_sc_hd__a22o_1
X_4648_ _8711_/Q _4637_/X _4647_/X _4639_/X VGND VGND VPWR VPWR _8711_/D sky130_fd_sc_hd__a22o_1
X_7436_ _7432_/X _7433_/X _7434_/X _7435_/X input16/X _7601_/S1 VGND VGND VPWR VPWR
+ _7436_/X sky130_fd_sc_hd__mux4_2
XFILLER_30_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_135_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4579_ _8741_/Q _4576_/X _4378_/X _4577_/X VGND VGND VPWR VPWR _8741_/D sky130_fd_sc_hd__a22o_1
X_7367_ _8605_/Q _8157_/Q _8509_/Q _8797_/Q _7389_/S0 _7390_/S1 VGND VGND VPWR VPWR
+ _7367_/X sky130_fd_sc_hd__mux4_2
XFILLER_131_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6318_ _6205_/X _6222_/X _6358_/A _6315_/X _6317_/X VGND VGND VPWR VPWR _6318_/X
+ sky130_fd_sc_hd__o311a_2
X_7298_ _8278_/Q _8246_/Q _8214_/Q _9014_/Q _7339_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7298_/X sky130_fd_sc_hd__mux4_1
X_9037_ _9037_/CLK _9037_/D VGND VGND VPWR VPWR _9037_/Q sky130_fd_sc_hd__dfxtp_1
X_6249_ input3/X _6249_/B VGND VGND VPWR VPWR _6249_/Y sky130_fd_sc_hd__nor2_1
XFILLER_29_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5620_ _8134_/Q _5618_/X _5467_/X _5619_/X VGND VGND VPWR VPWR _8134_/D sky130_fd_sc_hd__a22o_1
XFILLER_129_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5551_ _8181_/Q _5549_/X _5431_/X _5550_/X VGND VGND VPWR VPWR _8181_/D sky130_fd_sc_hd__a22o_1
X_8270_ _9038_/CLK _8270_/D VGND VGND VPWR VPWR _8270_/Q sky130_fd_sc_hd__dfxtp_1
X_4502_ _8794_/Q _4500_/X _4327_/X _4501_/X VGND VGND VPWR VPWR _8794_/D sky130_fd_sc_hd__a22o_1
X_5482_ _5482_/A _5723_/B VGND VGND VPWR VPWR _5522_/A sky130_fd_sc_hd__or2_4
X_7221_ _7217_/X _7218_/X _7219_/X _7220_/X _7241_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7221_/X sky130_fd_sc_hd__mux4_2
X_4433_ _8837_/Q _4430_/X _4378_/X _4431_/X VGND VGND VPWR VPWR _8837_/D sky130_fd_sc_hd__a22o_1
X_4364_ _4376_/A VGND VGND VPWR VPWR _4364_/X sky130_fd_sc_hd__clkbuf_2
X_7152_ _8808_/Q _8328_/Q _8936_/Q _8456_/Q _7374_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7152_/X sky130_fd_sc_hd__mux4_1
XFILLER_113_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4295_ _4302_/A VGND VGND VPWR VPWR _4295_/X sky130_fd_sc_hd__clkbuf_2
X_7083_ _8417_/Q _8289_/Q _8353_/Q _8545_/Q _7374_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7083_/X sky130_fd_sc_hd__mux4_1
X_6103_ _6677_/A _6452_/C VGND VGND VPWR VPWR _6103_/Y sky130_fd_sc_hd__nor2_1
X_6034_ _6034_/A VGND VGND VPWR VPWR _6664_/B sky130_fd_sc_hd__clkbuf_2
X_7985_ _8734_/Q _8702_/Q _8670_/Q _8638_/Q _8005_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7985_/X sky130_fd_sc_hd__mux4_2
XFILLER_94_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6936_ _6938_/X _6937_/X _6939_/S VGND VGND VPWR VPWR _6936_/X sky130_fd_sc_hd__mux2_1
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6867_ _6909_/X _6907_/X _6964_/S VGND VGND VPWR VPWR _6867_/X sky130_fd_sc_hd__mux2_1
XPHY_1949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8606_ _8958_/CLK _8606_/D VGND VGND VPWR VPWR _8606_/Q sky130_fd_sc_hd__dfxtp_1
X_5818_ _6975_/X _5818_/B VGND VGND VPWR VPWR _5819_/A sky130_fd_sc_hd__nand2_1
XFILLER_22_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6798_ _6628_/Y _6626_/Y _6809_/S VGND VGND VPWR VPWR _6798_/X sky130_fd_sc_hd__mux2_4
X_5749_ _5763_/A VGND VGND VPWR VPWR _5749_/X sky130_fd_sc_hd__buf_2
X_8537_ _8922_/CLK _8537_/D VGND VGND VPWR VPWR _8537_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_41_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8468_ _8947_/CLK _8468_/D VGND VGND VPWR VPWR _8468_/Q sky130_fd_sc_hd__dfxtp_1
X_7419_ _8098_/Q _8066_/Q _8034_/Q _9026_/Q _7655_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7419_/X sky130_fd_sc_hd__mux4_1
XFILLER_2_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8399_ _8975_/CLK _8399_/D VGND VGND VPWR VPWR _8399_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_89_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput80 _6719_/X VGND VGND VPWR VPWR regData[18] sky130_fd_sc_hd__clkbuf_2
XFILLER_110_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput91 _6739_/X VGND VGND VPWR VPWR regData[28] sky130_fd_sc_hd__clkbuf_2
X_4080_ _4647_/A VGND VGND VPWR VPWR _4080_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_63_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4982_ _8516_/Q _4978_/X _4928_/X _4979_/X VGND VGND VPWR VPWR _8516_/D sky130_fd_sc_hd__a22o_1
XFILLER_63_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7770_ _8979_/Q _8403_/Q _8179_/Q _8755_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7770_/X sky130_fd_sc_hd__mux4_1
XFILLER_16_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6721_ _6720_/X _9075_/Q _6733_/S VGND VGND VPWR VPWR _6721_/X sky130_fd_sc_hd__mux2_1
XFILLER_31_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6652_ _6614_/Y _6501_/D _6614_/A _6500_/A VGND VGND VPWR VPWR _6652_/X sky130_fd_sc_hd__o22a_1
X_5603_ _8145_/Q _5597_/X _5440_/X _5598_/X VGND VGND VPWR VPWR _8145_/D sky130_fd_sc_hd__a22o_1
XFILLER_31_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8322_ _8934_/CLK _8322_/D VGND VGND VPWR VPWR _8322_/Q sky130_fd_sc_hd__dfxtp_1
X_6583_ _6582_/A _6475_/Y _6582_/Y _6475_/A VGND VGND VPWR VPWR _6583_/X sky130_fd_sc_hd__o22a_1
X_5534_ _5570_/A VGND VGND VPWR VPWR _5571_/A sky130_fd_sc_hd__inv_2
XFILLER_127_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5465_ _8231_/Q _5454_/X _5464_/X _5456_/X VGND VGND VPWR VPWR _8231_/D sky130_fd_sc_hd__a22o_1
X_8253_ _9052_/CLK _8253_/D VGND VGND VPWR VPWR _8253_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_132_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4416_ _4430_/A VGND VGND VPWR VPWR _4416_/X sky130_fd_sc_hd__buf_2
X_7204_ _8525_/Q _8909_/Q _8845_/Q _8877_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7204_/X sky130_fd_sc_hd__mux4_1
X_8184_ _9048_/CLK _8184_/D VGND VGND VPWR VPWR _8184_/Q sky130_fd_sc_hd__dfxtp_1
X_7135_ _8710_/Q _8678_/Q _8646_/Q _8614_/Q _7135_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7135_/X sky130_fd_sc_hd__mux4_2
XFILLER_132_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5396_ _8262_/Q _5394_/X _5195_/X _5395_/X VGND VGND VPWR VPWR _8262_/D sky130_fd_sc_hd__a22o_1
XFILLER_101_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4347_ _8882_/Q _4338_/X _4346_/X _4340_/X VGND VGND VPWR VPWR _8882_/D sky130_fd_sc_hd__a22o_1
X_7066_ _6122_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7066_/X sky130_fd_sc_hd__mux2_2
X_4278_ _8920_/Q _4274_/X _4023_/X _4275_/X VGND VGND VPWR VPWR _8920_/D sky130_fd_sc_hd__a22o_1
XFILLER_100_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6017_ _6017_/A VGND VGND VPWR VPWR _6017_/Y sky130_fd_sc_hd__inv_2
XFILLER_36_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7968_ _8285_/Q _8253_/Q _8221_/Q _9021_/Q _8015_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7968_/X sky130_fd_sc_hd__mux4_1
XFILLER_27_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6919_ _6922_/X _6920_/X _6932_/S VGND VGND VPWR VPWR _6919_/X sky130_fd_sc_hd__mux2_1
X_7899_ _8122_/Q _8090_/Q _8058_/Q _9050_/Q input14/X _7900_/S1 VGND VGND VPWR VPWR
+ _7899_/X sky130_fd_sc_hd__mux4_2
XPHY_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5250_ _5250_/A VGND VGND VPWR VPWR _5250_/X sky130_fd_sc_hd__buf_2
XFILLER_130_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4201_ _8966_/Q _4199_/X _4083_/X _4200_/X VGND VGND VPWR VPWR _8966_/D sky130_fd_sc_hd__a22o_1
XFILLER_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5181_ _8396_/Q _5170_/X _5180_/X _5172_/X VGND VGND VPWR VPWR _8396_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4132_ _9010_/Q _4127_/X _4043_/X _4128_/X VGND VGND VPWR VPWR _9010_/D sky130_fd_sc_hd__a22o_1
XFILLER_110_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8940_ _8940_/CLK _8940_/D VGND VGND VPWR VPWR _8940_/Q sky130_fd_sc_hd__dfxtp_1
X_4063_ _4635_/A VGND VGND VPWR VPWR _4063_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_68_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8871_ _9056_/CLK _8871_/D VGND VGND VPWR VPWR _8871_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7822_ _8822_/Q _8342_/Q _8950_/Q _8470_/Q _7905_/S0 _7905_/S1 VGND VGND VPWR VPWR
+ _7822_/X sky130_fd_sc_hd__mux4_1
X_4965_ _4979_/A VGND VGND VPWR VPWR _4965_/X sky130_fd_sc_hd__buf_2
X_7753_ _8435_/Q _8307_/Q _8371_/Q _8563_/Q _7798_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7753_/X sky130_fd_sc_hd__mux4_1
X_6704_ _7186_/X _7191_/X _6704_/S VGND VGND VPWR VPWR _6704_/X sky130_fd_sc_hd__mux2_1
XPHY_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7684_ _8527_/Q _8911_/Q _8847_/Q _8879_/Q _7710_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7684_/X sky130_fd_sc_hd__mux4_1
X_4896_ _6795_/X VGND VGND VPWR VPWR _4896_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_137_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6635_ _6457_/A _6457_/B _6458_/B VGND VGND VPWR VPWR _6635_/X sky130_fd_sc_hd__a21bo_1
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6566_ _6465_/A _6471_/B _6438_/X VGND VGND VPWR VPWR _6566_/Y sky130_fd_sc_hd__o21ai_1
X_5517_ _8203_/Q _5515_/X _5455_/X _5516_/X VGND VGND VPWR VPWR _8203_/D sky130_fd_sc_hd__a22o_1
X_8305_ _8947_/CLK _8305_/D VGND VGND VPWR VPWR _8305_/Q sky130_fd_sc_hd__dfxtp_1
X_8236_ _8236_/CLK _8236_/D VGND VGND VPWR VPWR _8236_/Q sky130_fd_sc_hd__dfxtp_1
X_6497_ _6497_/A VGND VGND VPWR VPWR _6501_/C sky130_fd_sc_hd__inv_2
X_5448_ _6792_/X VGND VGND VPWR VPWR _5448_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_0_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8167_ _9031_/CLK _8167_/D VGND VGND VPWR VPWR _8167_/Q sky130_fd_sc_hd__dfxtp_1
X_5379_ _8273_/Q _5373_/X _5168_/X _5374_/X VGND VGND VPWR VPWR _8273_/D sky130_fd_sc_hd__a22o_1
XFILLER_120_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7118_ _8260_/Q _8228_/Q _8196_/Q _8996_/Q _7140_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7118_/X sky130_fd_sc_hd__mux4_2
X_8098_ _8994_/CLK _8098_/D VGND VGND VPWR VPWR _8098_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_87_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7049_ _7886_/X _7891_/X _7049_/S VGND VGND VPWR VPWR _7049_/X sky130_fd_sc_hd__mux2_2
XFILLER_74_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_2211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4750_ _8649_/Q _4746_/X _4643_/X _4747_/X VGND VGND VPWR VPWR _8649_/D sky130_fd_sc_hd__a22o_1
XFILLER_14_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4681_ _8696_/Q _4677_/X _4607_/X _4678_/X VGND VGND VPWR VPWR _8696_/D sky130_fd_sc_hd__a22o_1
X_6420_ _6780_/X _6779_/X _6778_/X _6809_/X VGND VGND VPWR VPWR _6422_/C sky130_fd_sc_hd__or4_4
X_6351_ _6333_/C _6350_/X _6333_/C _6350_/X VGND VGND VPWR VPWR _6351_/Y sky130_fd_sc_hd__a2bb2oi_1
X_5302_ _8324_/Q _5298_/X _5200_/X _5299_/X VGND VGND VPWR VPWR _8324_/D sky130_fd_sc_hd__a22o_1
X_6282_ _6282_/A _6282_/B VGND VGND VPWR VPWR _6415_/B sky130_fd_sc_hd__or2_2
X_9070_ _9075_/CLK _9070_/D repeater146/X VGND VGND VPWR VPWR _9070_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_88_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8021_ _8017_/X _8018_/X _8019_/X _8020_/X _6098_/A _8021_/S1 VGND VGND VPWR VPWR
+ _8021_/X sky130_fd_sc_hd__mux4_2
X_5233_ _8371_/Q _5229_/X _5164_/X _5230_/X VGND VGND VPWR VPWR _8371_/D sky130_fd_sc_hd__a22o_1
XFILLER_96_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5164_ _6797_/X VGND VGND VPWR VPWR _5164_/X sky130_fd_sc_hd__clkbuf_2
X_4115_ _9023_/Q _4109_/X _4111_/X _4114_/X VGND VGND VPWR VPWR _9023_/D sky130_fd_sc_hd__a22o_1
XFILLER_96_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5095_ _5102_/A VGND VGND VPWR VPWR _5095_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_110_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8923_ _8991_/CLK _8923_/D VGND VGND VPWR VPWR _8923_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_84_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4046_ _4623_/A VGND VGND VPWR VPWR _4046_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8854_ _8950_/CLK _8854_/D VGND VGND VPWR VPWR _8854_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7805_ _8725_/Q _8693_/Q _8661_/Q _8629_/Q _5872_/C _5872_/B VGND VGND VPWR VPWR
+ _7805_/X sky130_fd_sc_hd__mux4_1
XFILLER_52_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8785_ _8981_/CLK _8785_/D VGND VGND VPWR VPWR _8785_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_33_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5997_ _7035_/X _6037_/B VGND VGND VPWR VPWR _5998_/A sky130_fd_sc_hd__nand2_1
XFILLER_40_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4948_ _8540_/Q _4940_/X _4870_/X _4944_/X VGND VGND VPWR VPWR _8540_/D sky130_fd_sc_hd__a22o_1
X_7736_ _7732_/X _7733_/X _7734_/X _7735_/X _8031_/S0 _8001_/S1 VGND VGND VPWR VPWR
+ _7736_/X sky130_fd_sc_hd__mux4_2
XFILLER_12_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7667_ _8590_/Q _8142_/Q _8494_/Q _8782_/Q _7689_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7667_/X sky130_fd_sc_hd__mux4_2
X_4879_ _8569_/Q _4874_/X _4878_/X _4876_/X VGND VGND VPWR VPWR _8569_/D sky130_fd_sc_hd__a22o_1
XFILLER_138_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6618_ _6512_/B _6617_/X _6512_/B _6617_/X VGND VGND VPWR VPWR _6618_/Y sky130_fd_sc_hd__a2bb2oi_1
XFILLER_137_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7598_ _8267_/Q _8235_/Q _8203_/Q _9003_/Q _7599_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7598_/X sky130_fd_sc_hd__mux4_1
Xclkbuf_3_5_0_clk clkbuf_3_5_0_clk/A VGND VGND VPWR VPWR clkbuf_3_5_0_clk/X sky130_fd_sc_hd__clkbuf_1
XFILLER_118_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6549_ _6549_/A VGND VGND VPWR VPWR _6550_/D sky130_fd_sc_hd__inv_2
XFILLER_133_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8219_ _9020_/CLK _8219_/D VGND VGND VPWR VPWR _8219_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_102_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_2052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_2085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_136_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrepeater206 input29/X VGND VGND VPWR VPWR _6974_/S sky130_fd_sc_hd__buf_8
Xrepeater217 _7801_/S0 VGND VGND VPWR VPWR _7901_/S0 sky130_fd_sc_hd__buf_8
XFILLER_120_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater228 _7600_/S1 VGND VGND VPWR VPWR _7599_/S1 sky130_fd_sc_hd__buf_6
XFILLER_93_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater239 _8025_/S0 VGND VGND VPWR VPWR _8030_/S0 sky130_fd_sc_hd__buf_6
XFILLER_65_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5920_ _5920_/A _5920_/B VGND VGND VPWR VPWR _5920_/Y sky130_fd_sc_hd__nor2_1
XFILLER_65_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5851_ _7000_/X VGND VGND VPWR VPWR _5882_/A sky130_fd_sc_hd__inv_2
X_4802_ _4802_/A VGND VGND VPWR VPWR _4802_/X sky130_fd_sc_hd__clkbuf_2
X_5782_ _6854_/X VGND VGND VPWR VPWR _5782_/Y sky130_fd_sc_hd__inv_2
XFILLER_15_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8570_ _8954_/CLK _8570_/D VGND VGND VPWR VPWR _8570_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_34_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7521_ _7517_/X _7518_/X _7519_/X _7520_/X _5771_/C _7601_/S1 VGND VGND VPWR VPWR
+ _7521_/X sky130_fd_sc_hd__mux4_1
X_4733_ _4733_/A VGND VGND VPWR VPWR _4733_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_21_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7452_ _8804_/Q _8324_/Q _8932_/Q _8452_/Q _7579_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7452_/X sky130_fd_sc_hd__mux4_1
XFILLER_30_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6403_ _5931_/Y _6271_/A _6401_/Y _6402_/Y VGND VGND VPWR VPWR _6403_/Y sky130_fd_sc_hd__o22ai_1
X_4664_ _8704_/Q _4613_/A _4663_/X _4615_/A VGND VGND VPWR VPWR _8704_/D sky130_fd_sc_hd__a22o_1
XFILLER_116_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7383_ _8447_/Q _8319_/Q _8383_/Q _8575_/Q _6343_/A _6344_/B VGND VGND VPWR VPWR
+ _7383_/X sky130_fd_sc_hd__mux4_1
X_4595_ _4595_/A VGND VGND VPWR VPWR _4595_/X sky130_fd_sc_hd__clkbuf_2
X_6334_ _6185_/A _6324_/A _6321_/X VGND VGND VPWR VPWR _6335_/B sky130_fd_sc_hd__o21a_1
X_6265_ _6265_/A _6265_/B VGND VGND VPWR VPWR _6265_/X sky130_fd_sc_hd__or2_1
X_9053_ _9053_/CLK _9053_/D VGND VGND VPWR VPWR _9053_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_135_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8004_ _8543_/Q _8927_/Q _8863_/Q _8895_/Q _8005_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _8004_/X sky130_fd_sc_hd__mux4_2
X_5216_ _5230_/A VGND VGND VPWR VPWR _5216_/X sky130_fd_sc_hd__buf_2
XFILLER_88_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6196_ _6196_/A VGND VGND VPWR VPWR _6205_/B sky130_fd_sc_hd__inv_2
XFILLER_57_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5147_ _6804_/X VGND VGND VPWR VPWR _5147_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_28_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5078_ _8452_/Q _5074_/X _4928_/X _5075_/X VGND VGND VPWR VPWR _8452_/D sky130_fd_sc_hd__a22o_1
X_8906_ _8938_/CLK _8906_/D VGND VGND VPWR VPWR _8906_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_71_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4029_ _4611_/A VGND VGND VPWR VPWR _4029_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_71_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8837_ _8869_/CLK _8837_/D VGND VGND VPWR VPWR _8837_/Q sky130_fd_sc_hd__dfxtp_1
X_8768_ _8928_/CLK _8768_/D VGND VGND VPWR VPWR _8768_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_9_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7719_ _8113_/Q _8081_/Q _8049_/Q _9041_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7719_/X sky130_fd_sc_hd__mux4_1
X_8699_ _8731_/CLK _8699_/D VGND VGND VPWR VPWR _8699_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_126_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_88_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4380_ _4655_/A VGND VGND VPWR VPWR _4380_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_3_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_112_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6050_ _6673_/A _6518_/A _6059_/A _6049_/X VGND VGND VPWR VPWR _6050_/Y sky130_fd_sc_hd__o22ai_1
XFILLER_85_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5001_ _8505_/Q _4998_/X _4878_/X _4999_/X VGND VGND VPWR VPWR _8505_/D sky130_fd_sc_hd__a22o_1
XFILLER_94_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6952_ _7063_/X _7066_/X _6963_/S VGND VGND VPWR VPWR _6952_/X sky130_fd_sc_hd__mux2_1
XFILLER_53_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5903_ _5918_/A VGND VGND VPWR VPWR _5903_/Y sky130_fd_sc_hd__inv_2
X_6883_ _6942_/X _6941_/X _6939_/S VGND VGND VPWR VPWR _6883_/X sky130_fd_sc_hd__mux2_1
XFILLER_34_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5834_ _6851_/X _5780_/A _6854_/X _5890_/B VGND VGND VPWR VPWR _5834_/X sky130_fd_sc_hd__a22o_1
X_8622_ _8877_/CLK _8622_/D VGND VGND VPWR VPWR _8622_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_50_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8553_ _8841_/CLK _8553_/D VGND VGND VPWR VPWR _8553_/Q sky130_fd_sc_hd__dfxtp_1
X_5765_ _8037_/Q _5762_/X _4653_/A _5763_/X VGND VGND VPWR VPWR _8037_/D sky130_fd_sc_hd__a22o_1
X_7504_ _8518_/Q _8902_/Q _8838_/Q _8870_/Q _7505_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7504_/X sky130_fd_sc_hd__mux4_1
X_4716_ _4732_/A VGND VGND VPWR VPWR _4716_/X sky130_fd_sc_hd__clkbuf_2
X_8484_ _8966_/CLK _8484_/D VGND VGND VPWR VPWR _8484_/Q sky130_fd_sc_hd__dfxtp_1
X_5696_ _8084_/Q _5693_/X _4617_/A _5694_/X VGND VGND VPWR VPWR _8084_/D sky130_fd_sc_hd__a22o_1
X_7435_ _8707_/Q _8675_/Q _8643_/Q _8611_/Q _7579_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7435_/X sky130_fd_sc_hd__mux4_2
X_4647_ _4647_/A VGND VGND VPWR VPWR _4647_/X sky130_fd_sc_hd__buf_2
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7366_ _7362_/X _7363_/X _7364_/X _7365_/X _6343_/C _6343_/B VGND VGND VPWR VPWR
+ _7366_/X sky130_fd_sc_hd__mux4_2
XFILLER_30_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4578_ _8742_/Q _4576_/X _4375_/X _4577_/X VGND VGND VPWR VPWR _8742_/D sky130_fd_sc_hd__a22o_1
XFILLER_104_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6317_ _6185_/A _6220_/A _6217_/X _6316_/X VGND VGND VPWR VPWR _6317_/X sky130_fd_sc_hd__o211a_1
XFILLER_115_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7297_ _8598_/Q _8150_/Q _8502_/Q _8790_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7297_/X sky130_fd_sc_hd__mux4_1
XFILLER_89_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9036_ _9062_/CLK _9036_/D VGND VGND VPWR VPWR _9036_/Q sky130_fd_sc_hd__dfxtp_1
X_6248_ _6248_/A VGND VGND VPWR VPWR _6249_/B sky130_fd_sc_hd__inv_2
X_6179_ _9084_/Q _6167_/B _6168_/A VGND VGND VPWR VPWR _6181_/B sky130_fd_sc_hd__o21ai_1
XFILLER_39_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_96_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_70_clk clkbuf_4_14_0_clk/X VGND VGND VPWR VPWR _9027_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_31_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5550_ _5550_/A VGND VGND VPWR VPWR _5550_/X sky130_fd_sc_hd__buf_2
XFILLER_31_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5481_ _8224_/Q _5430_/A _5480_/X _5432_/A VGND VGND VPWR VPWR _8224_/D sky130_fd_sc_hd__a22o_1
X_4501_ _4508_/A VGND VGND VPWR VPWR _4501_/X sky130_fd_sc_hd__clkbuf_2
X_4432_ _8838_/Q _4430_/X _4375_/X _4431_/X VGND VGND VPWR VPWR _8838_/D sky130_fd_sc_hd__a22o_1
XANTENNA_0 _6096_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7220_ _8974_/Q _8398_/Q _8174_/Q _8750_/Q _7229_/S0 _7240_/S1 VGND VGND VPWR VPWR
+ _7220_/X sky130_fd_sc_hd__mux4_1
XFILLER_132_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4363_ _4638_/A VGND VGND VPWR VPWR _4363_/X sky130_fd_sc_hd__clkbuf_2
X_7151_ _7147_/X _7148_/X _7149_/X _7150_/X _7191_/S0 _7381_/S1 VGND VGND VPWR VPWR
+ _7151_/X sky130_fd_sc_hd__mux4_2
XFILLER_98_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7082_ _8801_/Q _8321_/Q _8929_/Q _8449_/Q _7374_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7082_/X sky130_fd_sc_hd__mux4_1
X_4294_ _8908_/Q _4288_/X _4063_/X _4289_/X VGND VGND VPWR VPWR _8908_/D sky130_fd_sc_hd__a22o_1
X_6102_ _6844_/X _5946_/X _6100_/X _6101_/Y VGND VGND VPWR VPWR _6102_/Y sky130_fd_sc_hd__o22ai_1
XFILLER_112_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6033_ _6033_/A VGND VGND VPWR VPWR _6034_/A sky130_fd_sc_hd__inv_2
XFILLER_100_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7984_ _8542_/Q _8926_/Q _8862_/Q _8894_/Q _7990_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7984_/X sky130_fd_sc_hd__mux4_2
XFILLER_81_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6935_ _7012_/X _7015_/X _6974_/S VGND VGND VPWR VPWR _6935_/X sky130_fd_sc_hd__mux2_1
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_61_clk clkbuf_4_15_0_clk/X VGND VGND VPWR VPWR _8966_/CLK sky130_fd_sc_hd__clkbuf_16
X_6866_ _6906_/X _6904_/X _6964_/S VGND VGND VPWR VPWR _6866_/X sky130_fd_sc_hd__mux2_1
XFILLER_50_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8605_ _8989_/CLK _8605_/D VGND VGND VPWR VPWR _8605_/Q sky130_fd_sc_hd__dfxtp_1
X_5817_ _6912_/X _5944_/B _6912_/X _5816_/A VGND VGND VPWR VPWR _5827_/A sky130_fd_sc_hd__o2bb2a_1
XFILLER_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6797_ _6634_/Y _6644_/X _6809_/S VGND VGND VPWR VPWR _6797_/X sky130_fd_sc_hd__mux2_4
X_5748_ _5762_/A VGND VGND VPWR VPWR _5748_/X sky130_fd_sc_hd__buf_2
XFILLER_10_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8536_ _8954_/CLK _8536_/D VGND VGND VPWR VPWR _8536_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_41_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5679_ _5715_/A VGND VGND VPWR VPWR _5694_/A sky130_fd_sc_hd__buf_4
X_8467_ _8882_/CLK _8467_/D VGND VGND VPWR VPWR _8467_/Q sky130_fd_sc_hd__dfxtp_1
X_7418_ _8258_/Q _8226_/Q _8194_/Q _8994_/Q _7655_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7418_/X sky130_fd_sc_hd__mux4_1
X_8398_ _8782_/CLK _8398_/D VGND VGND VPWR VPWR _8398_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_116_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7349_ _8123_/Q _8091_/Q _8059_/Q _9051_/Q _7359_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7349_/X sky130_fd_sc_hd__mux4_1
XFILLER_2_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_9019_ _9019_/CLK _9019_/D VGND VGND VPWR VPWR _9019_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_49_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_52_clk clkbuf_4_13_0_clk/X VGND VGND VPWR VPWR _8708_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_60_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput70 _9065_/Q VGND VGND VPWR VPWR imAddr[9] sky130_fd_sc_hd__clkbuf_2
XFILLER_68_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput81 _6721_/X VGND VGND VPWR VPWR regData[19] sky130_fd_sc_hd__clkbuf_2
Xoutput92 _6741_/X VGND VGND VPWR VPWR regData[29] sky130_fd_sc_hd__clkbuf_2
XFILLER_110_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4981_ _8517_/Q _4978_/X _4926_/X _4979_/X VGND VGND VPWR VPWR _8517_/D sky130_fd_sc_hd__a22o_1
XFILLER_51_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_43_clk _9063_/CLK VGND VGND VPWR VPWR _9000_/CLK sky130_fd_sc_hd__clkbuf_16
X_6720_ _7266_/X _7271_/X _6734_/S VGND VGND VPWR VPWR _6720_/X sky130_fd_sc_hd__mux2_1
X_6651_ _6455_/A _6455_/B _6456_/B VGND VGND VPWR VPWR _6651_/X sky130_fd_sc_hd__a21bo_1
XFILLER_32_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6582_ _6582_/A VGND VGND VPWR VPWR _6582_/Y sky130_fd_sc_hd__inv_2
X_5602_ _8146_/Q _5597_/X _5438_/X _5598_/X VGND VGND VPWR VPWR _8146_/D sky130_fd_sc_hd__a22o_1
X_8321_ _8926_/CLK _8321_/D VGND VGND VPWR VPWR _8321_/Q sky130_fd_sc_hd__dfxtp_1
X_5533_ _5549_/A VGND VGND VPWR VPWR _5533_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_117_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8252_ _9020_/CLK _8252_/D VGND VGND VPWR VPWR _8252_/Q sky130_fd_sc_hd__dfxtp_1
X_5464_ _6785_/X VGND VGND VPWR VPWR _5464_/X sky130_fd_sc_hd__clkbuf_2
X_5395_ _5395_/A VGND VGND VPWR VPWR _5395_/X sky130_fd_sc_hd__clkbuf_2
X_7203_ _8429_/Q _8301_/Q _8365_/Q _8557_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7203_/X sky130_fd_sc_hd__mux4_1
X_8183_ _9078_/CLK _8183_/D VGND VGND VPWR VPWR _8183_/Q sky130_fd_sc_hd__dfxtp_1
X_4415_ _8849_/Q _4409_/X _4348_/X _4410_/X VGND VGND VPWR VPWR _8849_/D sky130_fd_sc_hd__a22o_1
X_7134_ _8518_/Q _8902_/Q _8838_/Q _8870_/Q _7135_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7134_/X sky130_fd_sc_hd__mux4_1
XFILLER_99_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4346_ _4621_/A VGND VGND VPWR VPWR _4346_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_99_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7065_ _7996_/X _8001_/X _7071_/S VGND VGND VPWR VPWR _7065_/X sky130_fd_sc_hd__mux2_2
X_4277_ _8921_/Q _4274_/X _4019_/X _4275_/X VGND VGND VPWR VPWR _8921_/D sky130_fd_sc_hd__a22o_1
XFILLER_67_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6016_ _6016_/A VGND VGND VPWR VPWR _6016_/Y sky130_fd_sc_hd__inv_2
XFILLER_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_100_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7967_ _8605_/Q _8157_/Q _8509_/Q _8797_/Q _7990_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7967_/X sky130_fd_sc_hd__mux4_1
XFILLER_70_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_34_clk clkbuf_4_7_0_clk/X VGND VGND VPWR VPWR _8938_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_70_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6918_ _6925_/X _6919_/X _6918_/S VGND VGND VPWR VPWR _6918_/X sky130_fd_sc_hd__mux2_1
X_7898_ _8282_/Q _8250_/Q _8218_/Q _9018_/Q _7900_/S0 _7900_/S1 VGND VGND VPWR VPWR
+ _7898_/X sky130_fd_sc_hd__mux4_1
XFILLER_23_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6849_ _6932_/X _6925_/X _6918_/S VGND VGND VPWR VPWR _6849_/X sky130_fd_sc_hd__mux2_1
XFILLER_23_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8519_ _8811_/CLK _8519_/D VGND VGND VPWR VPWR _8519_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_2_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_89_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_93_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_25_clk clkbuf_4_5_0_clk/X VGND VGND VPWR VPWR _8863_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_14_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4200_ _4200_/A VGND VGND VPWR VPWR _4200_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_96_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5180_ _6790_/X VGND VGND VPWR VPWR _5180_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_68_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4131_ _9011_/Q _4127_/X _4040_/X _4128_/X VGND VGND VPWR VPWR _9011_/D sky130_fd_sc_hd__a22o_1
X_4062_ _6790_/X VGND VGND VPWR VPWR _4635_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_83_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8870_ _8934_/CLK _8870_/D VGND VGND VPWR VPWR _8870_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_52_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7821_ _7817_/X _7818_/X _7819_/X _7820_/X _7901_/S0 _8031_/S1 VGND VGND VPWR VPWR
+ _7821_/X sky130_fd_sc_hd__mux4_2
XFILLER_37_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_16_clk clkbuf_4_6_0_clk/X VGND VGND VPWR VPWR _8926_/CLK sky130_fd_sc_hd__clkbuf_16
X_4964_ _4978_/A VGND VGND VPWR VPWR _4964_/X sky130_fd_sc_hd__buf_2
XFILLER_51_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7752_ _8819_/Q _8339_/Q _8947_/Q _8467_/Q _7798_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7752_/X sky130_fd_sc_hd__mux4_1
X_6703_ _6702_/X _9066_/Q _6705_/S VGND VGND VPWR VPWR _6703_/X sky130_fd_sc_hd__mux2_1
XFILLER_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4895_ _8562_/Q _4886_/X _4894_/X _4888_/X VGND VGND VPWR VPWR _8562_/D sky130_fd_sc_hd__a22o_1
X_7683_ _8431_/Q _8303_/Q _8367_/Q _8559_/Q _7710_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7683_/X sky130_fd_sc_hd__mux4_1
XFILLER_137_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6634_ _6887_/X _6620_/X _6982_/X _6606_/X _6633_/Y VGND VGND VPWR VPWR _6634_/Y
+ sky130_fd_sc_hd__o221ai_2
XFILLER_20_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6565_ _6565_/A VGND VGND VPWR VPWR _6565_/X sky130_fd_sc_hd__buf_1
X_5516_ _5523_/A VGND VGND VPWR VPWR _5516_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_118_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6496_ _6829_/X _6008_/X _6829_/X _6008_/X VGND VGND VPWR VPWR _6497_/A sky130_fd_sc_hd__o2bb2a_1
X_8304_ _8816_/CLK _8304_/D VGND VGND VPWR VPWR _8304_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_118_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8235_ _9031_/CLK _8235_/D VGND VGND VPWR VPWR _8235_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_106_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5447_ _8239_/Q _5442_/X _5446_/X _5444_/X VGND VGND VPWR VPWR _8239_/D sky130_fd_sc_hd__a22o_1
XFILLER_133_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_114_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8166_ _8998_/CLK _8166_/D VGND VGND VPWR VPWR _8166_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_87_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5378_ _8274_/Q _5373_/X _5166_/X _5374_/X VGND VGND VPWR VPWR _8274_/D sky130_fd_sc_hd__a22o_1
XFILLER_114_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7117_ _8580_/Q _8132_/Q _8484_/Q _8772_/Q _7179_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7117_/X sky130_fd_sc_hd__mux4_2
XFILLER_99_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8097_ _9054_/CLK _8097_/D VGND VGND VPWR VPWR _8097_/Q sky130_fd_sc_hd__dfxtp_1
X_4329_ _8890_/Q _4326_/X _4327_/X _4328_/X VGND VGND VPWR VPWR _8890_/D sky130_fd_sc_hd__a22o_1
XFILLER_101_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7048_ _6384_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7048_/X sky130_fd_sc_hd__mux2_2
XFILLER_47_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8999_ _8999_/CLK _8999_/D VGND VGND VPWR VPWR _8999_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_70_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_2201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4680_ _8697_/Q _4677_/X _4605_/X _4678_/X VGND VGND VPWR VPWR _8697_/D sky130_fd_sc_hd__a22o_1
XFILLER_127_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6350_ _6333_/A _6333_/B _6318_/X _6335_/B VGND VGND VPWR VPWR _6350_/X sky130_fd_sc_hd__o31a_1
X_5301_ _8325_/Q _5298_/X _5198_/X _5299_/X VGND VGND VPWR VPWR _8325_/D sky130_fd_sc_hd__a22o_1
XFILLER_6_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_127_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6281_ _9057_/Q _6291_/B _9058_/Q _9059_/Q VGND VGND VPWR VPWR _6282_/B sky130_fd_sc_hd__a31oi_1
X_8020_ _8960_/Q _8384_/Q _8160_/Q _8736_/Q _5872_/C _5872_/B VGND VGND VPWR VPWR
+ _8020_/X sky130_fd_sc_hd__mux4_1
X_5232_ _8372_/Q _5229_/X _5162_/X _5230_/X VGND VGND VPWR VPWR _8372_/D sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_5_clk clkbuf_4_1_0_clk/X VGND VGND VPWR VPWR _8882_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_130_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5163_ _8404_/Q _5158_/X _5162_/X _5160_/X VGND VGND VPWR VPWR _8404_/D sky130_fd_sc_hd__a22o_1
XFILLER_111_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4114_ _4128_/A VGND VGND VPWR VPWR _4114_/X sky130_fd_sc_hd__buf_2
XFILLER_83_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5094_ _5101_/A VGND VGND VPWR VPWR _5094_/X sky130_fd_sc_hd__clkbuf_2
X_4045_ _6795_/X VGND VGND VPWR VPWR _4623_/A sky130_fd_sc_hd__buf_1
X_8922_ _8922_/CLK _8922_/D VGND VGND VPWR VPWR _8922_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8853_ _8945_/CLK _8853_/D VGND VGND VPWR VPWR _8853_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_92_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7804_ _8533_/Q _8917_/Q _8853_/Q _8885_/Q _5872_/C _5872_/B VGND VGND VPWR VPWR
+ _7804_/X sky130_fd_sc_hd__mux4_1
XPHY_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5996_ _5996_/A VGND VGND VPWR VPWR _5996_/X sky130_fd_sc_hd__clkbuf_2
X_8784_ _8816_/CLK _8784_/D VGND VGND VPWR VPWR _8784_/Q sky130_fd_sc_hd__dfxtp_1
X_4947_ _8541_/Q _4940_/X _4868_/X _4944_/X VGND VGND VPWR VPWR _8541_/D sky130_fd_sc_hd__a22o_1
X_7735_ _8722_/Q _8690_/Q _8658_/Q _8626_/Q _7919_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7735_/X sky130_fd_sc_hd__mux4_1
X_7666_ _7662_/X _7663_/X _7664_/X _7665_/X _7711_/S0 _6097_/A VGND VGND VPWR VPWR
+ _7666_/X sky130_fd_sc_hd__mux4_2
X_4878_ _6803_/X VGND VGND VPWR VPWR _4878_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_137_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6617_ _6503_/Y _5995_/A _6512_/A _6616_/X VGND VGND VPWR VPWR _6617_/X sky130_fd_sc_hd__o22a_1
X_7597_ _8587_/Q _8139_/Q _8491_/Q _8779_/Q _7599_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7597_/X sky130_fd_sc_hd__mux4_1
XFILLER_3_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6548_ _6502_/Y _6512_/Y _6614_/A _6547_/X VGND VGND VPWR VPWR _6549_/A sky130_fd_sc_hd__a31o_1
XFILLER_133_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6479_ _6819_/X _5988_/B _6476_/Y _5968_/A VGND VGND VPWR VPWR _6481_/A sky130_fd_sc_hd__a22o_1
XFILLER_3_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8218_ _9048_/CLK _8218_/D VGND VGND VPWR VPWR _8218_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_133_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8149_ _9013_/CLK _8149_/D VGND VGND VPWR VPWR _8149_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_87_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_2053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xrepeater207 input2/X VGND VGND VPWR VPWR _6948_/S sky130_fd_sc_hd__buf_8
Xrepeater229 _5772_/B VGND VGND VPWR VPWR _7600_/S1 sky130_fd_sc_hd__buf_8
XFILLER_93_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrepeater218 _8031_/S0 VGND VGND VPWR VPWR _7801_/S0 sky130_fd_sc_hd__buf_6
XFILLER_81_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5850_ _6847_/X _5844_/X _5846_/X _5849_/Y VGND VGND VPWR VPWR _5850_/Y sky130_fd_sc_hd__o22ai_1
X_4801_ _4801_/A VGND VGND VPWR VPWR _4801_/X sky130_fd_sc_hd__clkbuf_2
X_5781_ _6851_/X _5882_/B _6851_/X _5780_/A VGND VGND VPWR VPWR _6513_/A sky130_fd_sc_hd__a2bb2o_1
X_7520_ _8967_/Q _8391_/Q _8167_/Q _8743_/Q _7599_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7520_/X sky130_fd_sc_hd__mux4_1
X_4732_ _4732_/A VGND VGND VPWR VPWR _4732_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7451_ _7447_/X _7448_/X _7449_/X _7450_/X _7611_/S0 _7611_/S1 VGND VGND VPWR VPWR
+ _7451_/X sky130_fd_sc_hd__mux4_1
X_4663_ _4663_/A VGND VGND VPWR VPWR _4663_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_30_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6402_ _6402_/A _6402_/B VGND VGND VPWR VPWR _6402_/Y sky130_fd_sc_hd__nor2_1
XFILLER_119_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4594_ _8734_/Q _4588_/X _4593_/X _4591_/X VGND VGND VPWR VPWR _8734_/D sky130_fd_sc_hd__a22o_1
X_7382_ _8831_/Q _8351_/Q _8959_/Q _8479_/Q _6343_/A _7390_/S1 VGND VGND VPWR VPWR
+ _7382_/X sky130_fd_sc_hd__mux4_1
XFILLER_115_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6333_ _6333_/A _6333_/B _6333_/C _6333_/D VGND VGND VPWR VPWR _6333_/X sky130_fd_sc_hd__or4_4
XFILLER_115_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6264_ _6264_/A _6264_/B VGND VGND VPWR VPWR _6265_/B sky130_fd_sc_hd__or2_1
XFILLER_89_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9052_ _9052_/CLK _9052_/D VGND VGND VPWR VPWR _9052_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8003_ _8447_/Q _8319_/Q _8383_/Q _8575_/Q _8005_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _8003_/X sky130_fd_sc_hd__mux4_1
X_5215_ _5251_/A VGND VGND VPWR VPWR _5230_/A sky130_fd_sc_hd__clkbuf_4
Xclkbuf_4_15_0_clk clkbuf_3_7_0_clk/X VGND VGND VPWR VPWR clkbuf_4_15_0_clk/X sky130_fd_sc_hd__clkbuf_1
X_6195_ _6201_/A _6194_/A _6176_/A _6194_/Y VGND VGND VPWR VPWR _6196_/A sky130_fd_sc_hd__o22a_1
XFILLER_111_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5146_ _5158_/A VGND VGND VPWR VPWR _5146_/X sky130_fd_sc_hd__clkbuf_2
X_5077_ _8453_/Q _5074_/X _4926_/X _5075_/X VGND VGND VPWR VPWR _8453_/D sky130_fd_sc_hd__a22o_1
XFILLER_96_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8905_ _8938_/CLK _8905_/D VGND VGND VPWR VPWR _8905_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_72_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4028_ _6800_/X VGND VGND VPWR VPWR _4611_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_65_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8836_ _8868_/CLK _8836_/D VGND VGND VPWR VPWR _8836_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_52_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8767_ _8959_/CLK _8767_/D VGND VGND VPWR VPWR _8767_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_52_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5979_ _5979_/A VGND VGND VPWR VPWR _5979_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_12_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7718_ _8273_/Q _8241_/Q _8209_/Q _9009_/Q _7875_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7718_/X sky130_fd_sc_hd__mux4_2
XFILLER_40_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8698_ _9050_/CLK _8698_/D VGND VGND VPWR VPWR _8698_/Q sky130_fd_sc_hd__dfxtp_1
X_7649_ _8109_/Q _8077_/Q _8045_/Q _9037_/Q _7689_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7649_/X sky130_fd_sc_hd__mux4_1
XFILLER_119_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_106_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5000_ _8506_/Q _4998_/X _4875_/X _4999_/X VGND VGND VPWR VPWR _8506_/D sky130_fd_sc_hd__a22o_1
XFILLER_112_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6951_ _6953_/X _6952_/X _6961_/S VGND VGND VPWR VPWR _6951_/X sky130_fd_sc_hd__mux2_1
Xclkbuf_3_4_0_clk clkbuf_3_5_0_clk/A VGND VGND VPWR VPWR clkbuf_4_9_0_clk/A sky130_fd_sc_hd__clkbuf_1
X_6882_ _5929_/Y _6985_/X _6943_/S VGND VGND VPWR VPWR _6882_/X sky130_fd_sc_hd__mux2_2
X_5902_ _5890_/A _5870_/D _5866_/B VGND VGND VPWR VPWR _5902_/X sky130_fd_sc_hd__a21bo_1
X_5833_ _5788_/Y _5793_/A _5792_/X _5805_/X _5832_/X VGND VGND VPWR VPWR _5886_/A
+ sky130_fd_sc_hd__o2111a_2
X_8621_ _8877_/CLK _8621_/D VGND VGND VPWR VPWR _8621_/Q sky130_fd_sc_hd__dfxtp_1
X_8552_ _8669_/CLK _8552_/D VGND VGND VPWR VPWR _8552_/Q sky130_fd_sc_hd__dfxtp_1
X_7503_ _8422_/Q _8294_/Q _8358_/Q _8550_/Q _7505_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7503_/X sky130_fd_sc_hd__mux4_1
X_5764_ _8038_/Q _5762_/X _4650_/A _5763_/X VGND VGND VPWR VPWR _8038_/D sky130_fd_sc_hd__a22o_1
X_8483_ _8932_/CLK _8483_/D VGND VGND VPWR VPWR _8483_/Q sky130_fd_sc_hd__dfxtp_1
X_4715_ _4753_/A VGND VGND VPWR VPWR _4732_/A sky130_fd_sc_hd__clkbuf_4
X_5695_ _8085_/Q _5693_/X _4614_/A _5694_/X VGND VGND VPWR VPWR _8085_/D sky130_fd_sc_hd__a22o_1
X_4646_ _8712_/Q _4637_/X _4645_/X _4639_/X VGND VGND VPWR VPWR _8712_/D sky130_fd_sc_hd__a22o_1
X_7434_ _8515_/Q _8899_/Q _8835_/Q _8867_/Q _7599_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7434_/X sky130_fd_sc_hd__mux4_2
X_7365_ _8733_/Q _8701_/Q _8669_/Q _8637_/Q _6343_/A _6344_/B VGND VGND VPWR VPWR
+ _7365_/X sky130_fd_sc_hd__mux4_2
X_4577_ _4577_/A VGND VGND VPWR VPWR _4577_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_116_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6316_ _6201_/X _6212_/A _6208_/X VGND VGND VPWR VPWR _6316_/X sky130_fd_sc_hd__o21a_1
XFILLER_116_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7296_ _7292_/X _7293_/X _7294_/X _7295_/X _7341_/S0 _7336_/S1 VGND VGND VPWR VPWR
+ _7296_/X sky130_fd_sc_hd__mux4_2
X_9035_ _9035_/CLK _9035_/D VGND VGND VPWR VPWR _9035_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_89_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6247_ _6134_/B _6246_/X _6234_/B VGND VGND VPWR VPWR _6248_/A sky130_fd_sc_hd__a21bo_1
XFILLER_130_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6178_ _6178_/A VGND VGND VPWR VPWR _6178_/X sky130_fd_sc_hd__buf_2
XFILLER_130_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5129_ _8417_/Q _5101_/A _4934_/X _5102_/A VGND VGND VPWR VPWR _8417_/D sky130_fd_sc_hd__a22o_1
XFILLER_85_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8819_ _8882_/CLK _8819_/D VGND VGND VPWR VPWR _8819_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_139_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5480_ _6778_/X VGND VGND VPWR VPWR _5480_/X sky130_fd_sc_hd__clkbuf_2
X_4500_ _4507_/A VGND VGND VPWR VPWR _4500_/X sky130_fd_sc_hd__clkbuf_2
X_4431_ _4431_/A VGND VGND VPWR VPWR _4431_/X sky130_fd_sc_hd__buf_2
XANTENNA_1 _6099_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7150_ _8967_/Q _8391_/Q _8167_/Q _8743_/Q _7184_/S0 _7190_/S1 VGND VGND VPWR VPWR
+ _7150_/X sky130_fd_sc_hd__mux4_1
X_4362_ _4374_/A VGND VGND VPWR VPWR _4362_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_98_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4293_ _8909_/Q _4288_/X _4060_/X _4289_/X VGND VGND VPWR VPWR _8909_/D sky130_fd_sc_hd__a22o_1
X_7081_ _7077_/X _7078_/X _7079_/X _7080_/X _7286_/S0 _7381_/S1 VGND VGND VPWR VPWR
+ _7081_/X sky130_fd_sc_hd__mux4_2
X_6101_ _6101_/A _6101_/B VGND VGND VPWR VPWR _6101_/Y sky130_fd_sc_hd__nor2_1
XFILLER_100_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6032_ _7014_/X _6032_/B VGND VGND VPWR VPWR _6033_/A sky130_fd_sc_hd__nand2_1
XFILLER_39_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7983_ _8446_/Q _8318_/Q _8382_/Q _8574_/Q _8005_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7983_/X sky130_fd_sc_hd__mux4_2
XFILLER_67_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6934_ _7018_/X _7021_/X _6963_/S VGND VGND VPWR VPWR _6934_/X sky130_fd_sc_hd__mux2_1
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_8604_ _8956_/CLK _8604_/D VGND VGND VPWR VPWR _8604_/Q sky130_fd_sc_hd__dfxtp_1
X_6865_ _6866_/X _6433_/B _6949_/S VGND VGND VPWR VPWR _6865_/X sky130_fd_sc_hd__mux2_2
XPHY_1929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5816_ _5816_/A VGND VGND VPWR VPWR _5944_/B sky130_fd_sc_hd__buf_1
X_6796_ _6640_/Y _6638_/X _6809_/S VGND VGND VPWR VPWR _6796_/X sky130_fd_sc_hd__mux2_4
X_8535_ _8922_/CLK _8535_/D VGND VGND VPWR VPWR _8535_/Q sky130_fd_sc_hd__dfxtp_1
X_5747_ _8049_/Q _5741_/X _4623_/A _5742_/X VGND VGND VPWR VPWR _8049_/D sky130_fd_sc_hd__a22o_1
XFILLER_136_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8466_ _8882_/CLK _8466_/D VGND VGND VPWR VPWR _8466_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_136_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5678_ _5714_/A VGND VGND VPWR VPWR _5715_/A sky130_fd_sc_hd__inv_2
X_7417_ _8578_/Q _8130_/Q _8482_/Q _8770_/Q _7655_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7417_/X sky130_fd_sc_hd__mux4_1
X_8397_ _9037_/CLK _8397_/D VGND VGND VPWR VPWR _8397_/Q sky130_fd_sc_hd__dfxtp_1
X_4629_ _4629_/A VGND VGND VPWR VPWR _4629_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_104_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7348_ _8283_/Q _8251_/Q _8219_/Q _9019_/Q _7359_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7348_/X sky130_fd_sc_hd__mux4_2
XFILLER_2_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7279_ _8116_/Q _8084_/Q _8052_/Q _9044_/Q _7280_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7279_/X sky130_fd_sc_hd__mux4_2
XFILLER_131_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9018_ _9048_/CLK _9018_/D VGND VGND VPWR VPWR _9018_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_122_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_139_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_126_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput60 _9085_/Q VGND VGND VPWR VPWR imAddr[29] sky130_fd_sc_hd__clkbuf_2
Xoutput71 _6683_/X VGND VGND VPWR VPWR regData[0] sky130_fd_sc_hd__clkbuf_2
Xoutput82 _6685_/X VGND VGND VPWR VPWR regData[1] sky130_fd_sc_hd__clkbuf_2
Xoutput93 _6687_/X VGND VGND VPWR VPWR regData[2] sky130_fd_sc_hd__clkbuf_2
XFILLER_49_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4980_ _8518_/Q _4978_/X _4923_/X _4979_/X VGND VGND VPWR VPWR _8518_/D sky130_fd_sc_hd__a22o_1
XFILLER_63_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6650_ _6918_/X _6620_/X _6976_/X _6572_/A _6649_/Y VGND VGND VPWR VPWR _6650_/Y
+ sky130_fd_sc_hd__o221ai_2
XFILLER_31_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6581_ _6464_/A _6464_/B _6465_/B VGND VGND VPWR VPWR _6581_/X sky130_fd_sc_hd__a21bo_1
X_5601_ _8147_/Q _5597_/X _5436_/X _5598_/X VGND VGND VPWR VPWR _8147_/D sky130_fd_sc_hd__a22o_1
XFILLER_118_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5532_ _5570_/A VGND VGND VPWR VPWR _5549_/A sky130_fd_sc_hd__buf_4
X_8320_ _8928_/CLK _8320_/D VGND VGND VPWR VPWR _8320_/Q sky130_fd_sc_hd__dfxtp_1
X_5463_ _8232_/Q _5454_/X _5462_/X _5456_/X VGND VGND VPWR VPWR _8232_/D sky130_fd_sc_hd__a22o_1
X_8251_ _9020_/CLK _8251_/D VGND VGND VPWR VPWR _8251_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_8_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5394_ _5394_/A VGND VGND VPWR VPWR _5394_/X sky130_fd_sc_hd__buf_2
X_7202_ _8813_/Q _8333_/Q _8941_/Q _8461_/Q _7215_/S0 _7219_/S1 VGND VGND VPWR VPWR
+ _7202_/X sky130_fd_sc_hd__mux4_1
X_8182_ _9014_/CLK _8182_/D VGND VGND VPWR VPWR _8182_/Q sky130_fd_sc_hd__dfxtp_1
X_4414_ _8850_/Q _4409_/X _4346_/X _4410_/X VGND VGND VPWR VPWR _8850_/D sky130_fd_sc_hd__a22o_1
X_7133_ _8422_/Q _8294_/Q _8358_/Q _8550_/Q _7135_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7133_/X sky130_fd_sc_hd__mux4_1
X_4345_ _8883_/Q _4338_/X _4344_/X _4340_/X VGND VGND VPWR VPWR _8883_/D sky130_fd_sc_hd__a22o_1
XFILLER_113_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7064_ _7986_/X _7991_/X _7067_/S VGND VGND VPWR VPWR _7064_/X sky130_fd_sc_hd__mux2_1
X_4276_ _8922_/Q _4274_/X _4015_/X _4275_/X VGND VGND VPWR VPWR _8922_/D sky130_fd_sc_hd__a22o_1
XFILLER_67_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6015_ _6454_/A _6007_/A _6455_/A _6017_/A VGND VGND VPWR VPWR _6016_/A sky130_fd_sc_hd__o22a_1
XFILLER_55_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7966_ _7962_/X _7963_/X _7964_/X _7965_/X _8006_/S0 _8011_/S1 VGND VGND VPWR VPWR
+ _7966_/X sky130_fd_sc_hd__mux4_2
XFILLER_82_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6917_ _6916_/X _6918_/X _6948_/S VGND VGND VPWR VPWR _6917_/X sky130_fd_sc_hd__mux2_1
X_7897_ _8602_/Q _8154_/Q _8506_/Q _8794_/Q _7900_/S0 _7897_/S1 VGND VGND VPWR VPWR
+ _7897_/X sky130_fd_sc_hd__mux4_2
XPHY_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6848_ _5884_/X _7003_/X _6943_/S VGND VGND VPWR VPWR _6848_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8518_ _8868_/CLK _8518_/D VGND VGND VPWR VPWR _8518_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6779_ _5948_/Y _6089_/X _6809_/S VGND VGND VPWR VPWR _6779_/X sky130_fd_sc_hd__mux2_2
XFILLER_136_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8449_ _8926_/CLK _8449_/D VGND VGND VPWR VPWR _8449_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_123_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4130_ _9012_/Q _4127_/X _4036_/X _4128_/X VGND VGND VPWR VPWR _9012_/D sky130_fd_sc_hd__a22o_1
XFILLER_68_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4061_ _9037_/Q _4051_/X _4060_/X _4054_/X VGND VGND VPWR VPWR _9037_/D sky130_fd_sc_hd__a22o_1
XFILLER_83_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7820_ _8982_/Q _8406_/Q _8182_/Q _8758_/Q input14/X _7900_/S1 VGND VGND VPWR VPWR
+ _7820_/X sky130_fd_sc_hd__mux4_1
X_4963_ _8529_/Q _4957_/X _4896_/X _4958_/X VGND VGND VPWR VPWR _8529_/D sky130_fd_sc_hd__a22o_1
X_7751_ _7747_/X _7748_/X _7749_/X _7750_/X _7811_/S0 _8021_/S1 VGND VGND VPWR VPWR
+ _7751_/X sky130_fd_sc_hd__mux4_2
X_6702_ _7176_/X _7181_/X _6704_/S VGND VGND VPWR VPWR _6702_/X sky130_fd_sc_hd__mux2_1
X_7682_ _8815_/Q _8335_/Q _8943_/Q _8463_/Q _7710_/S0 _7909_/S1 VGND VGND VPWR VPWR
+ _7682_/X sky130_fd_sc_hd__mux4_2
X_6633_ _6456_/A _6002_/X _6621_/X VGND VGND VPWR VPWR _6633_/Y sky130_fd_sc_hd__o21ai_1
X_4894_ _6796_/X VGND VGND VPWR VPWR _4894_/X sky130_fd_sc_hd__clkbuf_2
X_6564_ _6570_/A _6564_/B VGND VGND VPWR VPWR _6565_/A sky130_fd_sc_hd__or2_1
X_5515_ _5522_/A VGND VGND VPWR VPWR _5515_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_106_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6495_ _6495_/A VGND VGND VPWR VPWR _6501_/B sky130_fd_sc_hd__inv_2
X_8303_ _8943_/CLK _8303_/D VGND VGND VPWR VPWR _8303_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_133_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8234_ _8970_/CLK _8234_/D VGND VGND VPWR VPWR _8234_/Q sky130_fd_sc_hd__dfxtp_1
X_5446_ _6793_/X VGND VGND VPWR VPWR _5446_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_133_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8165_ _9029_/CLK _8165_/D VGND VGND VPWR VPWR _8165_/Q sky130_fd_sc_hd__dfxtp_1
X_5377_ _8275_/Q _5373_/X _5164_/X _5374_/X VGND VGND VPWR VPWR _8275_/D sky130_fd_sc_hd__a22o_1
X_7116_ _7112_/X _7113_/X _7114_/X _7115_/X _7191_/S0 _7191_/S1 VGND VGND VPWR VPWR
+ _7116_/X sky130_fd_sc_hd__mux4_1
XFILLER_101_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8096_ _8822_/CLK _8096_/D VGND VGND VPWR VPWR _8096_/Q sky130_fd_sc_hd__dfxtp_1
X_4328_ _4340_/A VGND VGND VPWR VPWR _4328_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_86_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4259_ _8928_/Q _4230_/A _4103_/X _4231_/A VGND VGND VPWR VPWR _8928_/D sky130_fd_sc_hd__a22o_1
X_7047_ _7876_/X _7881_/X _7059_/S VGND VGND VPWR VPWR _7047_/X sky130_fd_sc_hd__mux2_2
XFILLER_28_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8998_ _8998_/CLK _8998_/D VGND VGND VPWR VPWR _8998_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_82_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_2202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7949_ _8124_/Q _8092_/Q _8060_/Q _9052_/Q _7949_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7949_/X sky130_fd_sc_hd__mux4_2
XFILLER_63_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5300_ _8326_/Q _5298_/X _5195_/X _5299_/X VGND VGND VPWR VPWR _8326_/D sky130_fd_sc_hd__a22o_1
XFILLER_115_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6280_ _9056_/Q VGND VGND VPWR VPWR _6291_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_115_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5231_ _8373_/Q _5229_/X _5159_/X _5230_/X VGND VGND VPWR VPWR _8373_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5162_ _6798_/X VGND VGND VPWR VPWR _5162_/X sky130_fd_sc_hd__buf_2
XFILLER_111_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5093_ _8443_/Q _5085_/X _4872_/X _5088_/X VGND VGND VPWR VPWR _8443_/D sky130_fd_sc_hd__a22o_1
X_4113_ _4149_/A VGND VGND VPWR VPWR _4128_/A sky130_fd_sc_hd__buf_4
XFILLER_68_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8921_ _8953_/CLK _8921_/D VGND VGND VPWR VPWR _8921_/Q sky130_fd_sc_hd__dfxtp_1
X_4044_ _9042_/Q _4034_/X _4043_/X _4037_/X VGND VGND VPWR VPWR _9042_/D sky130_fd_sc_hd__a22o_1
XFILLER_83_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8852_ _8947_/CLK _8852_/D VGND VGND VPWR VPWR _8852_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_64_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7803_ _8437_/Q _8309_/Q _8373_/Q _8565_/Q _5872_/C _5872_/B VGND VGND VPWR VPWR
+ _7803_/X sky130_fd_sc_hd__mux4_1
XFILLER_52_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8783_ _8816_/CLK _8783_/D VGND VGND VPWR VPWR _8783_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7734_ _8530_/Q _8914_/Q _8850_/Q _8882_/Q _7919_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7734_/X sky130_fd_sc_hd__mux4_1
XFILLER_24_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5995_ _5995_/A VGND VGND VPWR VPWR _5996_/A sky130_fd_sc_hd__inv_2
X_4946_ _8542_/Q _4940_/X _4866_/X _4944_/X VGND VGND VPWR VPWR _8542_/D sky130_fd_sc_hd__a22o_1
X_7665_ _8718_/Q _8686_/Q _8654_/Q _8622_/Q _7665_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7665_/X sky130_fd_sc_hd__mux4_2
X_4877_ _8570_/Q _4874_/X _4875_/X _4876_/X VGND VGND VPWR VPWR _8570_/D sky130_fd_sc_hd__a22o_1
XFILLER_32_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_119_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7596_ _7592_/X _7593_/X _7594_/X _7595_/X _5771_/C _5771_/B VGND VGND VPWR VPWR
+ _7596_/X sky130_fd_sc_hd__mux4_2
X_6616_ _6541_/A _6615_/X _6544_/A VGND VGND VPWR VPWR _6616_/X sky130_fd_sc_hd__o21a_1
XFILLER_20_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6547_ _6823_/X _5979_/X _6545_/X _6546_/X VGND VGND VPWR VPWR _6547_/X sky130_fd_sc_hd__o22a_1
XFILLER_133_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6478_ _6476_/Y _5968_/A _6477_/Y _5974_/A VGND VGND VPWR VPWR _6478_/X sky130_fd_sc_hd__a211o_1
X_8217_ _9049_/CLK _8217_/D VGND VGND VPWR VPWR _8217_/Q sky130_fd_sc_hd__dfxtp_1
X_5429_ _8246_/Q _5418_/X _5428_/X _5420_/X VGND VGND VPWR VPWR _8246_/D sky130_fd_sc_hd__a22o_1
XFILLER_58_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8148_ _8403_/CLK _8148_/D VGND VGND VPWR VPWR _8148_/Q sky130_fd_sc_hd__dfxtp_1
X_8079_ _8975_/CLK _8079_/D VGND VGND VPWR VPWR _8079_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_28_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_2010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_2098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xrepeater208 _7071_/S VGND VGND VPWR VPWR _7020_/S sky130_fd_sc_hd__buf_6
Xrepeater219 _7996_/S0 VGND VGND VPWR VPWR _8031_/S0 sky130_fd_sc_hd__buf_8
XFILLER_78_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4800_ _8615_/Q _4794_/X _4647_/X _4795_/X VGND VGND VPWR VPWR _8615_/D sky130_fd_sc_hd__a22o_1
XFILLER_22_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5780_ _5780_/A VGND VGND VPWR VPWR _5882_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_14_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4731_ _8662_/Q _4725_/X _4611_/X _4726_/X VGND VGND VPWR VPWR _8662_/D sky130_fd_sc_hd__a22o_1
XFILLER_119_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7450_ _8963_/Q _8387_/Q _8163_/Q _8739_/Q _7609_/S0 _7609_/S1 VGND VGND VPWR VPWR
+ _7450_/X sky130_fd_sc_hd__mux4_1
X_4662_ _8705_/Q _4613_/A _4661_/X _4615_/A VGND VGND VPWR VPWR _8705_/D sky130_fd_sc_hd__a22o_1
X_6401_ _6401_/A VGND VGND VPWR VPWR _6401_/Y sky130_fd_sc_hd__inv_2
XFILLER_30_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4593_ _4593_/A VGND VGND VPWR VPWR _4593_/X sky130_fd_sc_hd__clkbuf_2
X_7381_ _7377_/X _7378_/X _7379_/X _7380_/X _7391_/S0 _7381_/S1 VGND VGND VPWR VPWR
+ _7381_/X sky130_fd_sc_hd__mux4_1
XFILLER_115_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6332_ _6178_/A _6331_/Y _6201_/X _6331_/A VGND VGND VPWR VPWR _6333_/D sky130_fd_sc_hd__a22o_1
X_6263_ _6263_/A _6276_/A VGND VGND VPWR VPWR _6264_/B sky130_fd_sc_hd__or2_2
X_9051_ _9051_/CLK _9051_/D VGND VGND VPWR VPWR _9051_/Q sky130_fd_sc_hd__dfxtp_1
X_8002_ _8831_/Q _8351_/Q _8959_/Q _8479_/Q _8005_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _8002_/X sky130_fd_sc_hd__mux4_1
X_5214_ _5250_/A VGND VGND VPWR VPWR _5251_/A sky130_fd_sc_hd__clkinv_4
X_6194_ _6194_/A VGND VGND VPWR VPWR _6194_/Y sky130_fd_sc_hd__inv_2
XFILLER_97_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5145_ _8411_/Q _5133_/X _5144_/X _5136_/X VGND VGND VPWR VPWR _8411_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5076_ _8454_/Q _5074_/X _4923_/X _5075_/X VGND VGND VPWR VPWR _8454_/D sky130_fd_sc_hd__a22o_1
XFILLER_84_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8904_ _9056_/CLK _8904_/D VGND VGND VPWR VPWR _8904_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_84_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4027_ _9047_/Q _4017_/X _4026_/X _4020_/X VGND VGND VPWR VPWR _9047_/D sky130_fd_sc_hd__a22o_1
XFILLER_53_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8835_ _8934_/CLK _8835_/D VGND VGND VPWR VPWR _8835_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_44_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8766_ _8926_/CLK _8766_/D VGND VGND VPWR VPWR _8766_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5978_ _5978_/A VGND VGND VPWR VPWR _5979_/A sky130_fd_sc_hd__inv_2
X_4929_ _8548_/Q _4922_/X _4928_/X _4924_/X VGND VGND VPWR VPWR _8548_/D sky130_fd_sc_hd__a22o_1
X_8697_ _8729_/CLK _8697_/D VGND VGND VPWR VPWR _8697_/Q sky130_fd_sc_hd__dfxtp_1
X_7717_ _8593_/Q _8145_/Q _8497_/Q _8785_/Q _7875_/S0 _7780_/S1 VGND VGND VPWR VPWR
+ _7717_/X sky130_fd_sc_hd__mux4_2
XFILLER_40_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7648_ _8269_/Q _8237_/Q _8205_/Q _9005_/Q _7665_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7648_/X sky130_fd_sc_hd__mux4_1
X_7579_ _8106_/Q _8074_/Q _8042_/Q _9034_/Q _7579_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7579_/X sky130_fd_sc_hd__mux4_1
XFILLER_134_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_133_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_102_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6950_ _6954_/X _6951_/X _6964_/S VGND VGND VPWR VPWR _6950_/X sky130_fd_sc_hd__mux2_1
XFILLER_54_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5901_ _6857_/X _5844_/X _5846_/X _5900_/Y VGND VGND VPWR VPWR _5901_/Y sky130_fd_sc_hd__o22ai_1
XFILLER_35_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6881_ _6965_/X _6961_/X _6964_/S VGND VGND VPWR VPWR _6881_/X sky130_fd_sc_hd__mux2_1
X_5832_ _5832_/A _5832_/B _5832_/C _5832_/D VGND VGND VPWR VPWR _5832_/X sky130_fd_sc_hd__or4_4
X_8620_ _8876_/CLK _8620_/D VGND VGND VPWR VPWR _8620_/Q sky130_fd_sc_hd__dfxtp_1
X_5763_ _5763_/A VGND VGND VPWR VPWR _5763_/X sky130_fd_sc_hd__clkbuf_2
X_8551_ _8811_/CLK _8551_/D VGND VGND VPWR VPWR _8551_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_61_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7502_ _8806_/Q _8326_/Q _8934_/Q _8454_/Q _7610_/S0 _7505_/S1 VGND VGND VPWR VPWR
+ _7502_/X sky130_fd_sc_hd__mux4_1
X_4714_ _5210_/A _4762_/B VGND VGND VPWR VPWR _4753_/A sky130_fd_sc_hd__or2_4
X_8482_ _8998_/CLK _8482_/D VGND VGND VPWR VPWR _8482_/Q sky130_fd_sc_hd__dfxtp_1
X_5694_ _5694_/A VGND VGND VPWR VPWR _5694_/X sky130_fd_sc_hd__clkbuf_2
X_7433_ _8419_/Q _8291_/Q _8355_/Q _8547_/Q _7599_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7433_/X sky130_fd_sc_hd__mux4_1
XFILLER_107_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4645_ _4645_/A VGND VGND VPWR VPWR _4645_/X sky130_fd_sc_hd__buf_2
XFILLER_116_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4576_ _4576_/A VGND VGND VPWR VPWR _4576_/X sky130_fd_sc_hd__clkbuf_2
X_7364_ _8541_/Q _8925_/Q _8861_/Q _8893_/Q _7374_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7364_/X sky130_fd_sc_hd__mux4_1
X_6315_ _6201_/X _6203_/A _6199_/X _6314_/X VGND VGND VPWR VPWR _6315_/X sky130_fd_sc_hd__o211a_1
X_9034_ _9034_/CLK _9034_/D VGND VGND VPWR VPWR _9034_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_115_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_115_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7295_ _8726_/Q _8694_/Q _8662_/Q _8630_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7295_/X sky130_fd_sc_hd__mux4_2
XFILLER_130_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6246_ _6246_/A _6246_/B VGND VGND VPWR VPWR _6246_/X sky130_fd_sc_hd__or2_1
XFILLER_131_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6177_ _6177_/A VGND VGND VPWR VPWR _6178_/A sky130_fd_sc_hd__clkbuf_2
X_5128_ _8418_/Q _5122_/X _4932_/X _5123_/X VGND VGND VPWR VPWR _8418_/D sky130_fd_sc_hd__a22o_1
XFILLER_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5059_ _8465_/Q _5053_/X _4896_/X _5054_/X VGND VGND VPWR VPWR _8465_/D sky130_fd_sc_hd__a22o_1
XFILLER_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8818_ _8882_/CLK _8818_/D VGND VGND VPWR VPWR _8818_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_25_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8749_ _8781_/CLK _8749_/D VGND VGND VPWR VPWR _8749_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_134_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_14_0_clk clkbuf_3_7_0_clk/X VGND VGND VPWR VPWR clkbuf_4_14_0_clk/X sky130_fd_sc_hd__clkbuf_1
XPHY_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4430_ _4430_/A VGND VGND VPWR VPWR _4430_/X sky130_fd_sc_hd__buf_2
XANTENNA_2 _7012_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4361_ _8876_/Q _4350_/X _4360_/X _4352_/X VGND VGND VPWR VPWR _8876_/D sky130_fd_sc_hd__a22o_1
X_6100_ _6110_/C VGND VGND VPWR VPWR _6100_/X sky130_fd_sc_hd__clkbuf_2
X_7080_ _8960_/Q _8384_/Q _8160_/Q _8736_/Q _7369_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7080_/X sky130_fd_sc_hd__mux4_1
X_4292_ _8910_/Q _4288_/X _4057_/X _4289_/X VGND VGND VPWR VPWR _8910_/D sky130_fd_sc_hd__a22o_1
XFILLER_112_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6031_ _6031_/A VGND VGND VPWR VPWR _6658_/B sky130_fd_sc_hd__buf_1
XFILLER_58_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7982_ _8830_/Q _8350_/Q _8958_/Q _8478_/Q _8005_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7982_/X sky130_fd_sc_hd__mux4_1
XFILLER_54_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6933_ _6935_/X _6934_/X _6939_/S VGND VGND VPWR VPWR _6933_/X sky130_fd_sc_hd__mux2_1
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6864_ _6863_/X _6865_/X _6948_/S VGND VGND VPWR VPWR _6864_/X sky130_fd_sc_hd__mux2_1
X_5815_ _5815_/A VGND VGND VPWR VPWR _5816_/A sky130_fd_sc_hd__inv_2
X_8603_ _8956_/CLK _8603_/D VGND VGND VPWR VPWR _8603_/Q sky130_fd_sc_hd__dfxtp_1
XPHY_1919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6795_ _6650_/Y _6648_/X _6809_/S VGND VGND VPWR VPWR _6795_/X sky130_fd_sc_hd__mux2_4
XFILLER_10_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5746_ _8050_/Q _5741_/X _4621_/A _5742_/X VGND VGND VPWR VPWR _8050_/D sky130_fd_sc_hd__a22o_1
X_8534_ _8950_/CLK _8534_/D VGND VGND VPWR VPWR _8534_/Q sky130_fd_sc_hd__dfxtp_1
X_5677_ _5693_/A VGND VGND VPWR VPWR _5677_/X sky130_fd_sc_hd__clkbuf_2
X_8465_ _8945_/CLK _8465_/D VGND VGND VPWR VPWR _8465_/Q sky130_fd_sc_hd__dfxtp_1
X_7416_ _7412_/X _7413_/X _7414_/X _7415_/X _7501_/S0 _7601_/S1 VGND VGND VPWR VPWR
+ _7416_/X sky130_fd_sc_hd__mux4_2
X_4628_ _8720_/Q _4625_/X _4626_/X _4627_/X VGND VGND VPWR VPWR _8720_/D sky130_fd_sc_hd__a22o_1
X_8396_ _9004_/CLK _8396_/D VGND VGND VPWR VPWR _8396_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_116_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_7347_ _8603_/Q _8155_/Q _8507_/Q _8795_/Q _7359_/S0 _7349_/S1 VGND VGND VPWR VPWR
+ _7347_/X sky130_fd_sc_hd__mux4_1
X_4559_ _8755_/Q _4555_/X _4344_/X _4556_/X VGND VGND VPWR VPWR _8755_/D sky130_fd_sc_hd__a22o_1
X_7278_ _8276_/Q _8244_/Q _8212_/Q _9012_/Q _7280_/S0 _7334_/S1 VGND VGND VPWR VPWR
+ _7278_/X sky130_fd_sc_hd__mux4_1
XFILLER_104_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9017_ _9049_/CLK _9017_/D VGND VGND VPWR VPWR _9017_/Q sky130_fd_sc_hd__dfxtp_1
X_6229_ _6129_/B _6223_/X _6129_/B _6223_/X VGND VGND VPWR VPWR _6232_/B sky130_fd_sc_hd__a2bb2o_1
XFILLER_106_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_3_0_clk clkbuf_3_3_0_clk/A VGND VGND VPWR VPWR clkbuf_4_7_0_clk/A sky130_fd_sc_hd__clkbuf_1
XFILLER_31_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput61 _9058_/Q VGND VGND VPWR VPWR imAddr[2] sky130_fd_sc_hd__clkbuf_2
XFILLER_122_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput50 _9057_/Q VGND VGND VPWR VPWR imAddr[1] sky130_fd_sc_hd__clkbuf_2
Xoutput72 _6703_/X VGND VGND VPWR VPWR regData[10] sky130_fd_sc_hd__clkbuf_2
Xoutput94 _6743_/X VGND VGND VPWR VPWR regData[30] sky130_fd_sc_hd__clkbuf_2
XFILLER_110_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput83 _6723_/X VGND VGND VPWR VPWR regData[20] sky130_fd_sc_hd__clkbuf_2
XFILLER_122_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6580_ _6121_/X _6436_/X _7006_/X _6572_/X _6579_/Y VGND VGND VPWR VPWR _6580_/Y
+ sky130_fd_sc_hd__o221ai_2
X_5600_ _8148_/Q _5597_/X _5434_/X _5598_/X VGND VGND VPWR VPWR _8148_/D sky130_fd_sc_hd__a22o_1
XFILLER_118_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5531_ _5531_/A _5723_/B VGND VGND VPWR VPWR _5570_/A sky130_fd_sc_hd__or2_4
X_8250_ _8986_/CLK _8250_/D VGND VGND VPWR VPWR _8250_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_117_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7201_ _7197_/X _7198_/X _7199_/X _7200_/X _7241_/S0 _7341_/S1 VGND VGND VPWR VPWR
+ _7201_/X sky130_fd_sc_hd__mux4_2
X_5462_ _6786_/X VGND VGND VPWR VPWR _5462_/X sky130_fd_sc_hd__clkbuf_2
X_5393_ _8263_/Q _5387_/X _5192_/X _5388_/X VGND VGND VPWR VPWR _8263_/D sky130_fd_sc_hd__a22o_1
X_8181_ _8981_/CLK _8181_/D VGND VGND VPWR VPWR _8181_/Q sky130_fd_sc_hd__dfxtp_1
X_4413_ _8851_/Q _4409_/X _4344_/X _4410_/X VGND VGND VPWR VPWR _8851_/D sky130_fd_sc_hd__a22o_1
X_7132_ _8806_/Q _8326_/Q _8934_/Q _8454_/Q _7135_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7132_/X sky130_fd_sc_hd__mux4_1
X_4344_ _4619_/A VGND VGND VPWR VPWR _4344_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_101_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7063_ _6348_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7063_/X sky130_fd_sc_hd__mux2_2
XFILLER_59_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4275_ _4282_/A VGND VGND VPWR VPWR _4275_/X sky130_fd_sc_hd__clkbuf_2
X_6014_ _7026_/X _6032_/B VGND VGND VPWR VPWR _6017_/A sky130_fd_sc_hd__nand2_2
XFILLER_100_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7965_ _8733_/Q _8701_/Q _8669_/Q _8637_/Q _8005_/S0 _7985_/S1 VGND VGND VPWR VPWR
+ _7965_/X sky130_fd_sc_hd__mux4_2
XFILLER_54_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6916_ _6915_/X _6932_/X _6918_/S VGND VGND VPWR VPWR _6916_/X sky130_fd_sc_hd__mux2_1
X_7896_ _7892_/X _7893_/X _7894_/X _7895_/X _7901_/S0 _8031_/S1 VGND VGND VPWR VPWR
+ _7896_/X sky130_fd_sc_hd__mux4_1
XFILLER_35_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6847_ _6846_/X _5842_/X _6948_/S VGND VGND VPWR VPWR _6847_/X sky130_fd_sc_hd__mux2_1
XFILLER_22_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6778_ _6087_/Y _6080_/Y _6809_/S VGND VGND VPWR VPWR _6778_/X sky130_fd_sc_hd__mux2_2
XFILLER_10_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8517_ _8709_/CLK _8517_/D VGND VGND VPWR VPWR _8517_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_109_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5729_ _8063_/Q _5725_/X _4668_/A _5728_/X VGND VGND VPWR VPWR _8063_/D sky130_fd_sc_hd__a22o_1
XFILLER_136_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_108_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8448_ _8928_/CLK _8448_/D VGND VGND VPWR VPWR _8448_/Q sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_111_clk clkbuf_4_2_0_clk/X VGND VGND VPWR VPWR _8665_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_123_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8379_ _8956_/CLK _8379_/D VGND VGND VPWR VPWR _8379_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_104_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4060_ _4633_/A VGND VGND VPWR VPWR _4060_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_95_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4962_ _8530_/Q _4957_/X _4894_/X _4958_/X VGND VGND VPWR VPWR _8530_/D sky130_fd_sc_hd__a22o_1
XFILLER_51_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7750_ _8978_/Q _8402_/Q _8178_/Q _8754_/Q _7808_/S0 _7808_/S1 VGND VGND VPWR VPWR
+ _7750_/X sky130_fd_sc_hd__mux4_1
X_6701_ _6700_/X _9065_/Q _6705_/S VGND VGND VPWR VPWR _6701_/X sky130_fd_sc_hd__mux2_1
X_7681_ _7677_/X _7678_/X _7679_/X _7680_/X _7701_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7681_/X sky130_fd_sc_hd__mux4_1
X_4893_ _8563_/Q _4886_/X _4892_/X _4888_/X VGND VGND VPWR VPWR _8563_/D sky130_fd_sc_hd__a22o_1
XFILLER_60_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_6632_ _6604_/X _7019_/X VGND VGND VPWR VPWR _6632_/Y sky130_fd_sc_hd__nand2b_1
XFILLER_20_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6563_ _6410_/X _7034_/X VGND VGND VPWR VPWR _6563_/Y sky130_fd_sc_hd__nand2b_1
X_5514_ _8204_/Q _5508_/X _5452_/X _5509_/X VGND VGND VPWR VPWR _8204_/D sky130_fd_sc_hd__a22o_1
X_8302_ _8781_/CLK _8302_/D VGND VGND VPWR VPWR _8302_/Q sky130_fd_sc_hd__dfxtp_1
X_6494_ _6493_/Y _6017_/A _6828_/X _6017_/Y VGND VGND VPWR VPWR _6495_/A sky130_fd_sc_hd__o22a_1
X_8233_ _8586_/CLK _8233_/D VGND VGND VPWR VPWR _8233_/Q sky130_fd_sc_hd__dfxtp_1
X_5445_ _8240_/Q _5442_/X _5443_/X _5444_/X VGND VGND VPWR VPWR _8240_/D sky130_fd_sc_hd__a22o_1
X_8164_ _9027_/CLK _8164_/D VGND VGND VPWR VPWR _8164_/Q sky130_fd_sc_hd__dfxtp_1
X_7115_ _8708_/Q _8676_/Q _8644_/Q _8612_/Q _7179_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7115_/X sky130_fd_sc_hd__mux4_1
XFILLER_120_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5376_ _8276_/Q _5373_/X _5162_/X _5374_/X VGND VGND VPWR VPWR _8276_/D sky130_fd_sc_hd__a22o_1
X_8095_ _9051_/CLK _8095_/D VGND VGND VPWR VPWR _8095_/Q sky130_fd_sc_hd__dfxtp_1
X_4327_ _4602_/A VGND VGND VPWR VPWR _4327_/X sky130_fd_sc_hd__clkbuf_2
X_4258_ _8929_/Q _4230_/A _4100_/X _4231_/A VGND VGND VPWR VPWR _8929_/D sky130_fd_sc_hd__a22o_1
XFILLER_59_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7046_ _7866_/X _7871_/X _7070_/S VGND VGND VPWR VPWR _7046_/X sky130_fd_sc_hd__mux2_1
X_4189_ _8974_/Q _4185_/X _4057_/X _4186_/X VGND VGND VPWR VPWR _8974_/D sky130_fd_sc_hd__a22o_1
XFILLER_28_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_103_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8997_ _8998_/CLK _8997_/D VGND VGND VPWR VPWR _8997_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_82_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7948_ _8284_/Q _8252_/Q _8220_/Q _9020_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _7948_/X sky130_fd_sc_hd__mux4_1
XPHY_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_7879_ _8121_/Q _8089_/Q _8057_/Q _9049_/Q _7900_/S0 input15/X VGND VGND VPWR VPWR
+ _7879_/X sky130_fd_sc_hd__mux4_2
XFILLER_23_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_128_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_104_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_115_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5230_ _5230_/A VGND VGND VPWR VPWR _5230_/X sky130_fd_sc_hd__buf_2
XFILLER_130_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5161_ _8405_/Q _5158_/X _5159_/X _5160_/X VGND VGND VPWR VPWR _8405_/D sky130_fd_sc_hd__a22o_1
XFILLER_110_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5092_ _8444_/Q _5085_/X _4870_/X _5088_/X VGND VGND VPWR VPWR _8444_/D sky130_fd_sc_hd__a22o_1
X_4112_ _4148_/A VGND VGND VPWR VPWR _4149_/A sky130_fd_sc_hd__inv_2
XFILLER_69_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8920_ _8952_/CLK _8920_/D VGND VGND VPWR VPWR _8920_/Q sky130_fd_sc_hd__dfxtp_1
X_4043_ _4621_/A VGND VGND VPWR VPWR _4043_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_25_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8851_ _8947_/CLK _8851_/D VGND VGND VPWR VPWR _8851_/Q sky130_fd_sc_hd__dfxtp_1
X_8782_ _8782_/CLK _8782_/D VGND VGND VPWR VPWR _8782_/Q sky130_fd_sc_hd__dfxtp_1
X_7802_ _8821_/Q _8341_/Q _8949_/Q _8469_/Q _5872_/C _5872_/B VGND VGND VPWR VPWR
+ _7802_/X sky130_fd_sc_hd__mux4_1
X_5994_ _7038_/X _5994_/B VGND VGND VPWR VPWR _5995_/A sky130_fd_sc_hd__nand2_1
X_4945_ _8543_/Q _4940_/X _4941_/X _4944_/X VGND VGND VPWR VPWR _8543_/D sky130_fd_sc_hd__a22o_1
X_7733_ _8434_/Q _8306_/Q _8370_/Q _8562_/Q _7919_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7733_/X sky130_fd_sc_hd__mux4_2
X_7664_ _8526_/Q _8910_/Q _8846_/Q _8878_/Q _7665_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7664_/X sky130_fd_sc_hd__mux4_1
X_4876_ _4888_/A VGND VGND VPWR VPWR _4876_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_137_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7595_ _8715_/Q _8683_/Q _8651_/Q _8619_/Q _7595_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7595_/X sky130_fd_sc_hd__mux4_2
X_6615_ _6614_/Y _6502_/A _6541_/B VGND VGND VPWR VPWR _6615_/X sky130_fd_sc_hd__o21a_1
XFILLER_137_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6546_ _6824_/X _5996_/X _6823_/X _5979_/A VGND VGND VPWR VPWR _6546_/X sky130_fd_sc_hd__a22o_1
XFILLER_106_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6477_ _6820_/X VGND VGND VPWR VPWR _6477_/Y sky130_fd_sc_hd__inv_2
X_8216_ _9048_/CLK _8216_/D VGND VGND VPWR VPWR _8216_/Q sky130_fd_sc_hd__dfxtp_1
X_5428_ _6800_/X VGND VGND VPWR VPWR _5428_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_99_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5359_ _5395_/A VGND VGND VPWR VPWR _5374_/A sky130_fd_sc_hd__buf_4
XFILLER_58_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8147_ _8787_/CLK _8147_/D VGND VGND VPWR VPWR _8147_/Q sky130_fd_sc_hd__dfxtp_1
X_8078_ _8782_/CLK _8078_/D VGND VGND VPWR VPWR _8078_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_101_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7029_ _7756_/X _7761_/X _7059_/S VGND VGND VPWR VPWR _7029_/X sky130_fd_sc_hd__mux2_2
XFILLER_47_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_2000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_105_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xrepeater209 _7071_/S VGND VGND VPWR VPWR _7059_/S sky130_fd_sc_hd__buf_6
XFILLER_66_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4730_ _8663_/Q _4725_/X _4609_/X _4726_/X VGND VGND VPWR VPWR _8663_/D sky130_fd_sc_hd__a22o_1
XFILLER_21_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4661_ _4661_/A VGND VGND VPWR VPWR _4661_/X sky130_fd_sc_hd__clkbuf_2
X_7380_ _8990_/Q _8414_/Q _8190_/Q _8766_/Q _7389_/S0 _7380_/S1 VGND VGND VPWR VPWR
+ _7380_/X sky130_fd_sc_hd__mux4_1
X_6400_ _6398_/Y _6399_/Y _6398_/Y _6399_/Y VGND VGND VPWR VPWR _6400_/X sky130_fd_sc_hd__o2bb2a_1
X_4592_ _8735_/Q _4588_/X _4393_/X _4591_/X VGND VGND VPWR VPWR _8735_/D sky130_fd_sc_hd__a22o_1
XFILLER_116_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6331_ _6331_/A VGND VGND VPWR VPWR _6331_/Y sky130_fd_sc_hd__inv_2
XFILLER_127_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6262_ _6244_/Y _6248_/A _6249_/Y _6251_/X _6261_/X VGND VGND VPWR VPWR _6262_/X
+ sky130_fd_sc_hd__o221a_1
X_9050_ _9050_/CLK _9050_/D VGND VGND VPWR VPWR _9050_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_130_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5213_ _6809_/X VGND VGND VPWR VPWR _5213_/X sky130_fd_sc_hd__buf_2
X_8001_ _7997_/X _7998_/X _7999_/X _8000_/X _8031_/S0 _8001_/S1 VGND VGND VPWR VPWR
+ _8001_/X sky130_fd_sc_hd__mux4_1
X_6193_ _9073_/Q _6149_/B _6150_/A VGND VGND VPWR VPWR _6194_/A sky130_fd_sc_hd__o21ai_2
X_5144_ _6805_/X VGND VGND VPWR VPWR _5144_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_111_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_84_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5075_ _5075_/A VGND VGND VPWR VPWR _5075_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_84_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8903_ _9056_/CLK _8903_/D VGND VGND VPWR VPWR _8903_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_56_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4026_ _4609_/A VGND VGND VPWR VPWR _4026_/X sky130_fd_sc_hd__clkbuf_2
X_8834_ _8933_/CLK _8834_/D VGND VGND VPWR VPWR _8834_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_52_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_91_clk clkbuf_4_8_0_clk/X VGND VGND VPWR VPWR _9086_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_25_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8765_ _8958_/CLK _8765_/D VGND VGND VPWR VPWR _8765_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5977_ _7041_/X _5994_/B VGND VGND VPWR VPWR _5978_/A sky130_fd_sc_hd__nand2_1
X_4928_ _6782_/X VGND VGND VPWR VPWR _4928_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_12_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8696_ _8757_/CLK _8696_/D VGND VGND VPWR VPWR _8696_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_40_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7716_ _7712_/X _7713_/X _7714_/X _7715_/X _7801_/S0 _8001_/S1 VGND VGND VPWR VPWR
+ _7716_/X sky130_fd_sc_hd__mux4_1
X_7647_ _8589_/Q _8141_/Q _8493_/Q _8781_/Q _7665_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7647_/X sky130_fd_sc_hd__mux4_2
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4859_ _5035_/A _5307_/B VGND VGND VPWR VPWR _4922_/A sky130_fd_sc_hd__or2_4
X_7578_ _8266_/Q _8234_/Q _8202_/Q _9002_/Q _7600_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7578_/X sky130_fd_sc_hd__mux4_1
XFILLER_109_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6529_ _6839_/X _6673_/B _6842_/X _6677_/B VGND VGND VPWR VPWR _6529_/X sky130_fd_sc_hd__a22o_1
XFILLER_134_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_82_clk clkbuf_4_11_0_clk/X VGND VGND VPWR VPWR _8877_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_43_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_112_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5900_ _5900_/A _5900_/B VGND VGND VPWR VPWR _5900_/Y sky130_fd_sc_hd__nor2_1
XFILLER_53_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6880_ _6958_/X _6954_/X _6964_/S VGND VGND VPWR VPWR _6880_/X sky130_fd_sc_hd__mux2_1
XFILLER_46_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5831_ _5831_/A VGND VGND VPWR VPWR _5832_/D sky130_fd_sc_hd__inv_2
XFILLER_62_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8550_ _8709_/CLK _8550_/D VGND VGND VPWR VPWR _8550_/Q sky130_fd_sc_hd__dfxtp_1
X_5762_ _5762_/A VGND VGND VPWR VPWR _5762_/X sky130_fd_sc_hd__clkbuf_2
X_7501_ _7497_/X _7498_/X _7499_/X _7500_/X _7501_/S0 _7701_/S1 VGND VGND VPWR VPWR
+ _7501_/X sky130_fd_sc_hd__mux4_1
X_4713_ _8672_/Q _4684_/A _4663_/X _4685_/A VGND VGND VPWR VPWR _8672_/D sky130_fd_sc_hd__a22o_1
X_8481_ _8926_/CLK _8481_/D VGND VGND VPWR VPWR _8481_/Q sky130_fd_sc_hd__dfxtp_1
X_5693_ _5693_/A VGND VGND VPWR VPWR _5693_/X sky130_fd_sc_hd__clkbuf_2
X_4644_ _8713_/Q _4637_/X _4643_/X _4639_/X VGND VGND VPWR VPWR _8713_/D sky130_fd_sc_hd__a22o_1
X_7432_ _8803_/Q _8323_/Q _8931_/Q _8451_/Q _7599_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7432_/X sky130_fd_sc_hd__mux4_1
X_4575_ _8743_/Q _4569_/X _4372_/X _4570_/X VGND VGND VPWR VPWR _8743_/D sky130_fd_sc_hd__a22o_1
X_7363_ _8445_/Q _8317_/Q _8381_/Q _8573_/Q _7374_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7363_/X sky130_fd_sc_hd__mux4_1
XFILLER_116_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6314_ _6201_/X _6194_/A _6191_/X VGND VGND VPWR VPWR _6314_/X sky130_fd_sc_hd__o21a_1
X_7294_ _8534_/Q _8918_/Q _8854_/Q _8886_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7294_/X sky130_fd_sc_hd__mux4_1
X_9033_ _9033_/CLK _9033_/D VGND VGND VPWR VPWR _9033_/Q sky130_fd_sc_hd__dfxtp_1
X_6245_ _6245_/A _6255_/A _6255_/B VGND VGND VPWR VPWR _6246_/B sky130_fd_sc_hd__or3_4
XFILLER_130_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_130_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_97_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6176_ _6176_/A VGND VGND VPWR VPWR _6177_/A sky130_fd_sc_hd__buf_2
X_5127_ _8419_/Q _5122_/X _4930_/X _5123_/X VGND VGND VPWR VPWR _8419_/D sky130_fd_sc_hd__a22o_1
XFILLER_69_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5058_ _8466_/Q _5053_/X _4894_/X _5054_/X VGND VGND VPWR VPWR _8466_/D sky130_fd_sc_hd__a22o_1
XFILLER_45_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_85_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4009_ _4597_/A VGND VGND VPWR VPWR _4009_/X sky130_fd_sc_hd__clkbuf_2
Xclkbuf_leaf_64_clk clkbuf_4_14_0_clk/X VGND VGND VPWR VPWR _8994_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_25_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8817_ _8821_/CLK _8817_/D VGND VGND VPWR VPWR _8817_/Q sky130_fd_sc_hd__dfxtp_1
X_8748_ _8780_/CLK _8748_/D VGND VGND VPWR VPWR _8748_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_52_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8679_ _8713_/CLK _8679_/D VGND VGND VPWR VPWR _8679_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_21_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_55_clk clkbuf_4_15_0_clk/X VGND VGND VPWR VPWR _8868_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_16_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_3 _4252_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4360_ _4635_/A VGND VGND VPWR VPWR _4360_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_6_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_98_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4291_ _8911_/Q _4288_/X _4053_/X _4289_/X VGND VGND VPWR VPWR _8911_/D sky130_fd_sc_hd__a22o_1
X_6030_ _6030_/A VGND VGND VPWR VPWR _6031_/A sky130_fd_sc_hd__inv_2
XFILLER_79_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7981_ _7977_/X _7978_/X _7979_/X _7980_/X _8031_/S0 _5771_/B VGND VGND VPWR VPWR
+ _7981_/X sky130_fd_sc_hd__mux4_1
XFILLER_67_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_46_clk _9063_/CLK VGND VGND VPWR VPWR _9031_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_81_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6932_ _6936_/X _6933_/X _6932_/S VGND VGND VPWR VPWR _6932_/X sky130_fd_sc_hd__mux2_1
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6863_ _6862_/X _6867_/X _6949_/S VGND VGND VPWR VPWR _6863_/X sky130_fd_sc_hd__mux2_1
XFILLER_50_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5814_ _6978_/X _5818_/B VGND VGND VPWR VPWR _5815_/A sky130_fd_sc_hd__nand2_1
XFILLER_50_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8602_ _8986_/CLK _8602_/D VGND VGND VPWR VPWR _8602_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_35_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_1909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6794_ _6654_/Y _6652_/X _6809_/S VGND VGND VPWR VPWR _6794_/X sky130_fd_sc_hd__mux2_4
X_8533_ _8821_/CLK _8533_/D VGND VGND VPWR VPWR _8533_/Q sky130_fd_sc_hd__dfxtp_1
X_5745_ _8051_/Q _5741_/X _4619_/A _5742_/X VGND VGND VPWR VPWR _8051_/D sky130_fd_sc_hd__a22o_1
X_5676_ _5714_/A VGND VGND VPWR VPWR _5693_/A sky130_fd_sc_hd__buf_4
X_8464_ _8942_/CLK _8464_/D VGND VGND VPWR VPWR _8464_/Q sky130_fd_sc_hd__dfxtp_1
X_7415_ _8706_/Q _8674_/Q _8642_/Q _8610_/Q _7480_/S0 _7579_/S1 VGND VGND VPWR VPWR
+ _7415_/X sky130_fd_sc_hd__mux4_2
XFILLER_108_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4627_ _4651_/A VGND VGND VPWR VPWR _4627_/X sky130_fd_sc_hd__clkbuf_2
X_8395_ _9033_/CLK _8395_/D VGND VGND VPWR VPWR _8395_/Q sky130_fd_sc_hd__dfxtp_1
X_7346_ _7342_/X _7343_/X _7344_/X _7345_/X _6343_/C _6343_/B VGND VGND VPWR VPWR
+ _7346_/X sky130_fd_sc_hd__mux4_2
X_4558_ _8756_/Q _4555_/X _4342_/X _4556_/X VGND VGND VPWR VPWR _8756_/D sky130_fd_sc_hd__a22o_1
XFILLER_104_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4489_ _4537_/A _5579_/B VGND VGND VPWR VPWR _4528_/A sky130_fd_sc_hd__or2_4
X_7277_ _8596_/Q _8148_/Q _8500_/Q _8788_/Q _7280_/S0 _7288_/S1 VGND VGND VPWR VPWR
+ _7277_/X sky130_fd_sc_hd__mux4_2
XFILLER_131_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_9016_ _9048_/CLK _9016_/D VGND VGND VPWR VPWR _9016_/Q sky130_fd_sc_hd__dfxtp_1
X_6228_ _6176_/A _6227_/B _6227_/Y VGND VGND VPWR VPWR _6311_/A sky130_fd_sc_hd__a21o_1
X_6159_ _9080_/Q _6159_/B VGND VGND VPWR VPWR _6160_/A sky130_fd_sc_hd__nand2_1
XFILLER_97_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_leaf_37_clk clkbuf_4_7_0_clk/X VGND VGND VPWR VPWR _8811_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_26_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput40 _9066_/Q VGND VGND VPWR VPWR imAddr[10] sky130_fd_sc_hd__clkbuf_2
XFILLER_107_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput51 _9076_/Q VGND VGND VPWR VPWR imAddr[20] sky130_fd_sc_hd__clkbuf_2
Xoutput84 _6725_/X VGND VGND VPWR VPWR regData[21] sky130_fd_sc_hd__clkbuf_2
Xoutput73 _6705_/X VGND VGND VPWR VPWR regData[11] sky130_fd_sc_hd__clkbuf_2
XFILLER_96_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput62 _9086_/Q VGND VGND VPWR VPWR imAddr[30] sky130_fd_sc_hd__clkbuf_2
Xoutput95 _6745_/X VGND VGND VPWR VPWR regData[31] sky130_fd_sc_hd__clkbuf_2
XFILLER_95_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_28_clk clkbuf_4_5_0_clk/X VGND VGND VPWR VPWR _8732_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_91_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5530_ _8192_/Q _5501_/A _5480_/X _5502_/A VGND VGND VPWR VPWR _8192_/D sky130_fd_sc_hd__a22o_1
X_5461_ _8233_/Q _5454_/X _5460_/X _5456_/X VGND VGND VPWR VPWR _8233_/D sky130_fd_sc_hd__a22o_1
XFILLER_8_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_117_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7200_ _8972_/Q _8396_/Q _8172_/Q _8748_/Q _7229_/S0 _7210_/S1 VGND VGND VPWR VPWR
+ _7200_/X sky130_fd_sc_hd__mux4_1
X_4412_ _8852_/Q _4409_/X _4342_/X _4410_/X VGND VGND VPWR VPWR _8852_/D sky130_fd_sc_hd__a22o_1
XFILLER_126_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5392_ _8264_/Q _5387_/X _5190_/X _5388_/X VGND VGND VPWR VPWR _8264_/D sky130_fd_sc_hd__a22o_1
X_8180_ _9009_/CLK _8180_/D VGND VGND VPWR VPWR _8180_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_126_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7131_ _7127_/X _7128_/X _7129_/X _7130_/X input35/X _7191_/S1 VGND VGND VPWR VPWR
+ _7131_/X sky130_fd_sc_hd__mux4_1
X_4343_ _8884_/Q _4338_/X _4342_/X _4340_/X VGND VGND VPWR VPWR _8884_/D sky130_fd_sc_hd__a22o_1
XFILLER_99_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7062_ _7976_/X _7981_/X _7071_/S VGND VGND VPWR VPWR _7062_/X sky130_fd_sc_hd__mux2_1
X_4274_ _4281_/A VGND VGND VPWR VPWR _4274_/X sky130_fd_sc_hd__clkbuf_2
X_6013_ _7027_/X VGND VGND VPWR VPWR _6455_/A sky130_fd_sc_hd__inv_2
XFILLER_100_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7964_ _8541_/Q _8925_/Q _8861_/Q _8893_/Q _7990_/S0 _8009_/S1 VGND VGND VPWR VPWR
+ _7964_/X sky130_fd_sc_hd__mux4_1
XFILLER_94_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_19_clk clkbuf_4_4_0_clk/X VGND VGND VPWR VPWR _9053_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_82_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6915_ _6914_/X _6939_/X _6932_/S VGND VGND VPWR VPWR _6915_/X sky130_fd_sc_hd__mux2_1
XFILLER_42_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7895_ _8730_/Q _8698_/Q _8666_/Q _8634_/Q _7895_/S0 _7895_/S1 VGND VGND VPWR VPWR
+ _7895_/X sky130_fd_sc_hd__mux4_2
XPHY_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6846_ _6908_/X _6905_/X _6949_/S VGND VGND VPWR VPWR _6846_/X sky130_fd_sc_hd__mux2_1
XPHY_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6777_ _6342_/Y _6173_/Y _6777_/S VGND VGND VPWR VPWR _9087_/D sky130_fd_sc_hd__mux2_1
X_8516_ _8932_/CLK _8516_/D VGND VGND VPWR VPWR _8516_/Q sky130_fd_sc_hd__dfxtp_1
X_3989_ _3989_/A _3989_/B _3989_/C VGND VGND VPWR VPWR _3990_/D sky130_fd_sc_hd__or3_1
X_5728_ _5742_/A VGND VGND VPWR VPWR _5728_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_10_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5659_ _5666_/A VGND VGND VPWR VPWR _5659_/X sky130_fd_sc_hd__buf_2
X_8447_ _8735_/CLK _8447_/D VGND VGND VPWR VPWR _8447_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_136_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8378_ _9050_/CLK _8378_/D VGND VGND VPWR VPWR _8378_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_123_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7329_ _8121_/Q _8089_/Q _8057_/Q _9049_/Q _7340_/S0 _7340_/S1 VGND VGND VPWR VPWR
+ _7329_/X sky130_fd_sc_hd__mux4_2
XFILLER_104_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_13_0_clk clkbuf_3_6_0_clk/X VGND VGND VPWR VPWR clkbuf_4_13_0_clk/X sky130_fd_sc_hd__clkbuf_1
XFILLER_46_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_122_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4961_ _8531_/Q _4957_/X _4892_/X _4958_/X VGND VGND VPWR VPWR _8531_/D sky130_fd_sc_hd__a22o_1
X_6700_ _7166_/X _7171_/X _6704_/S VGND VGND VPWR VPWR _6700_/X sky130_fd_sc_hd__mux2_1
X_4892_ _6797_/X VGND VGND VPWR VPWR _4892_/X sky130_fd_sc_hd__clkbuf_2
X_7680_ _8975_/Q _8399_/Q _8175_/Q _8751_/Q _7700_/S0 _7700_/S1 VGND VGND VPWR VPWR
+ _7680_/X sky130_fd_sc_hd__mux4_1
X_6631_ _6511_/A _6630_/X _6511_/A _6630_/X VGND VGND VPWR VPWR _6631_/Y sky130_fd_sc_hd__a2bb2oi_1
X_8301_ _8780_/CLK _8301_/D VGND VGND VPWR VPWR _8301_/Q sky130_fd_sc_hd__dfxtp_1
X_6562_ _6436_/X _6560_/X _7018_/X _6110_/B _6561_/Y VGND VGND VPWR VPWR _6562_/Y
+ sky130_fd_sc_hd__o221ai_2
XFILLER_20_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5513_ _8205_/Q _5508_/X _5450_/X _5509_/X VGND VGND VPWR VPWR _8205_/D sky130_fd_sc_hd__a22o_1
X_6493_ _6828_/X VGND VGND VPWR VPWR _6493_/Y sky130_fd_sc_hd__inv_2
XFILLER_118_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8232_ _9000_/CLK _8232_/D VGND VGND VPWR VPWR _8232_/Q sky130_fd_sc_hd__dfxtp_1
X_5444_ _5468_/A VGND VGND VPWR VPWR _5444_/X sky130_fd_sc_hd__clkbuf_2
Xclkbuf_leaf_8_clk clkbuf_4_1_0_clk/X VGND VGND VPWR VPWR _8725_/CLK sky130_fd_sc_hd__clkbuf_16
XFILLER_133_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8163_ _9027_/CLK _8163_/D VGND VGND VPWR VPWR _8163_/Q sky130_fd_sc_hd__dfxtp_1
X_7114_ _8516_/Q _8900_/Q _8836_/Q _8868_/Q _7135_/S0 _7180_/S1 VGND VGND VPWR VPWR
+ _7114_/X sky130_fd_sc_hd__mux4_1
X_5375_ _8277_/Q _5373_/X _5159_/X _5374_/X VGND VGND VPWR VPWR _8277_/D sky130_fd_sc_hd__a22o_1
XFILLER_87_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8094_ _8725_/CLK _8094_/D VGND VGND VPWR VPWR _8094_/Q sky130_fd_sc_hd__dfxtp_1
X_4326_ _4338_/A VGND VGND VPWR VPWR _4326_/X sky130_fd_sc_hd__clkbuf_2
X_4257_ _8930_/Q _4251_/X _4097_/X _4252_/X VGND VGND VPWR VPWR _8930_/D sky130_fd_sc_hd__a22o_1
XFILLER_101_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7045_ _6395_/Y _6114_/X _7069_/S VGND VGND VPWR VPWR _7045_/X sky130_fd_sc_hd__mux2_2
XFILLER_28_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4188_ _8975_/Q _4185_/X _4053_/X _4186_/X VGND VGND VPWR VPWR _8975_/D sky130_fd_sc_hd__a22o_1
XFILLER_95_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8996_ _9004_/CLK _8996_/D VGND VGND VPWR VPWR _8996_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_55_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_2_0_clk clkbuf_3_3_0_clk/A VGND VGND VPWR VPWR clkbuf_4_5_0_clk/A sky130_fd_sc_hd__clkbuf_1
X_7947_ _8604_/Q _8156_/Q _8508_/Q _8796_/Q _8010_/S0 _8010_/S1 VGND VGND VPWR VPWR
+ _7947_/X sky130_fd_sc_hd__mux4_2
XPHY_2226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7878_ _8281_/Q _8249_/Q _8217_/Q _9017_/Q _7900_/S0 _7900_/S1 VGND VGND VPWR VPWR
+ _7878_/X sky130_fd_sc_hd__mux4_1
XPHY_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_6829_ _6656_/Y _7024_/X _6830_/S VGND VGND VPWR VPWR _6829_/X sky130_fd_sc_hd__mux2_1
XPHY_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_137_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_136_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_124_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_132_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_123_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5160_ _5160_/A VGND VGND VPWR VPWR _5160_/X sky130_fd_sc_hd__buf_2
XFILLER_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5091_ _8445_/Q _5085_/X _4868_/X _5088_/X VGND VGND VPWR VPWR _8445_/D sky130_fd_sc_hd__a22o_1
X_4111_ _4668_/A VGND VGND VPWR VPWR _4111_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_111_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4042_ _6796_/X VGND VGND VPWR VPWR _4621_/A sky130_fd_sc_hd__buf_1
XFILLER_76_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8850_ _8947_/CLK _8850_/D VGND VGND VPWR VPWR _8850_/Q sky130_fd_sc_hd__dfxtp_1
X_5993_ _5993_/A _5993_/B _5993_/C _5992_/X VGND VGND VPWR VPWR _6028_/B sky130_fd_sc_hd__or4b_4
XFILLER_64_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8781_ _8781_/CLK _8781_/D VGND VGND VPWR VPWR _8781_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_25_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7801_ _7797_/X _7798_/X _7799_/X _7800_/X _7801_/S0 _8001_/S1 VGND VGND VPWR VPWR
+ _7801_/X sky130_fd_sc_hd__mux4_2
X_4944_ _4958_/A VGND VGND VPWR VPWR _4944_/X sky130_fd_sc_hd__buf_2
X_7732_ _8818_/Q _8338_/Q _8946_/Q _8466_/Q _7919_/S0 _7999_/S1 VGND VGND VPWR VPWR
+ _7732_/X sky130_fd_sc_hd__mux4_1
XFILLER_40_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7663_ _8430_/Q _8302_/Q _8366_/Q _8558_/Q _7665_/S0 _7665_/S1 VGND VGND VPWR VPWR
+ _7663_/X sky130_fd_sc_hd__mux4_1
X_4875_ _6804_/X VGND VGND VPWR VPWR _4875_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_33_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7594_ _8523_/Q _8907_/Q _8843_/Q _8875_/Q _7594_/S0 _7595_/S1 VGND VGND VPWR VPWR
+ _7594_/X sky130_fd_sc_hd__mux4_1
X_6614_ _6614_/A VGND VGND VPWR VPWR _6614_/Y sky130_fd_sc_hd__inv_2
XFILLER_118_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6545_ _6824_/X _5996_/A _6541_/Y _6544_/Y VGND VGND VPWR VPWR _6545_/X sky130_fd_sc_hd__o22a_1
X_8215_ _9049_/CLK _8215_/D VGND VGND VPWR VPWR _8215_/Q sky130_fd_sc_hd__dfxtp_1
X_6476_ _6819_/X VGND VGND VPWR VPWR _6476_/Y sky130_fd_sc_hd__inv_2
X_5427_ _8247_/Q _5418_/X _5426_/X _5420_/X VGND VGND VPWR VPWR _8247_/D sky130_fd_sc_hd__a22o_1
X_5358_ _5394_/A VGND VGND VPWR VPWR _5395_/A sky130_fd_sc_hd__inv_2
XFILLER_87_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8146_ _8787_/CLK _8146_/D VGND VGND VPWR VPWR _8146_/Q sky130_fd_sc_hd__dfxtp_1
X_4309_ _8897_/Q _4281_/A _4100_/X _4282_/A VGND VGND VPWR VPWR _8897_/D sky130_fd_sc_hd__a22o_1
XFILLER_87_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8077_ _9037_/CLK _8077_/D VGND VGND VPWR VPWR _8077_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_114_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_5289_ _8333_/Q _5284_/X _5178_/X _5285_/X VGND VGND VPWR VPWR _8333_/D sky130_fd_sc_hd__a22o_1
XFILLER_75_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7028_ _7746_/X _7751_/X _7070_/S VGND VGND VPWR VPWR _7028_/X sky130_fd_sc_hd__mux2_2
XFILLER_75_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8979_ _9012_/CLK _8979_/D VGND VGND VPWR VPWR _8979_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_28_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_2001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_2034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_2089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_2078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_109_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4660_ _8706_/Q _4649_/X _4659_/X _4651_/X VGND VGND VPWR VPWR _8706_/D sky130_fd_sc_hd__a22o_1
XFILLER_30_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4591_ _4615_/A VGND VGND VPWR VPWR _4591_/X sky130_fd_sc_hd__clkbuf_2
X_6330_ _6178_/A _6328_/Y _6335_/A VGND VGND VPWR VPWR _6333_/C sky130_fd_sc_hd__o21ai_2
XFILLER_127_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_6261_ _6308_/A _6308_/B _6261_/C VGND VGND VPWR VPWR _6261_/X sky130_fd_sc_hd__or3_2
XFILLER_115_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5212_ _5229_/A VGND VGND VPWR VPWR _5212_/X sky130_fd_sc_hd__buf_2
XFILLER_97_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8000_ _8991_/Q _8415_/Q _8191_/Q _8767_/Q _8000_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _8000_/X sky130_fd_sc_hd__mux4_1
XFILLER_69_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6192_ _6177_/A _6189_/Y _6191_/X VGND VGND VPWR VPWR _6205_/A sky130_fd_sc_hd__o21ai_2
XFILLER_97_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5143_ _8412_/Q _5133_/X _5142_/X _5136_/X VGND VGND VPWR VPWR _8412_/D sky130_fd_sc_hd__a22o_1
XFILLER_97_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5074_ _5074_/A VGND VGND VPWR VPWR _5074_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_69_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8902_ _8934_/CLK _8902_/D VGND VGND VPWR VPWR _8902_/Q sky130_fd_sc_hd__dfxtp_1
X_4025_ _6801_/X VGND VGND VPWR VPWR _4609_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_37_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_8833_ _9057_/CLK _8833_/D VGND VGND VPWR VPWR _8833_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_53_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8764_ _8991_/CLK _8764_/D VGND VGND VPWR VPWR _8764_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5976_ _5976_/A _5976_/B VGND VGND VPWR VPWR _5993_/B sky130_fd_sc_hd__or2_1
XFILLER_13_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_4927_ _8549_/Q _4922_/X _4926_/X _4924_/X VGND VGND VPWR VPWR _8549_/D sky130_fd_sc_hd__a22o_1
X_7715_ _8721_/Q _8689_/Q _8657_/Q _8625_/Q _8030_/S0 _8030_/S1 VGND VGND VPWR VPWR
+ _7715_/X sky130_fd_sc_hd__mux4_2
X_8695_ _8729_/CLK _8695_/D VGND VGND VPWR VPWR _8695_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_138_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4858_ _4858_/A _4858_/B _6812_/X VGND VGND VPWR VPWR _5307_/B sky130_fd_sc_hd__or3_4
X_7646_ _7642_/X _7643_/X _7644_/X _7645_/X _7711_/S0 _6097_/A VGND VGND VPWR VPWR
+ _7646_/X sky130_fd_sc_hd__mux4_2
XFILLER_21_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_7577_ _8586_/Q _8138_/Q _8490_/Q _8778_/Q _7600_/S0 _7600_/S1 VGND VGND VPWR VPWR
+ _7577_/X sky130_fd_sc_hd__mux4_2
XFILLER_134_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4789_ _8624_/Q _4787_/X _4626_/X _4788_/X VGND VGND VPWR VPWR _8624_/D sky130_fd_sc_hd__a22o_1
XFILLER_134_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6528_ _6528_/A _6528_/B VGND VGND VPWR VPWR _6528_/Y sky130_fd_sc_hd__nor2_1
XFILLER_109_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6459_ _6459_/A _6612_/A _6612_/B VGND VGND VPWR VPWR _6460_/B sky130_fd_sc_hd__or3_1
XFILLER_121_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8129_ _9054_/CLK _8129_/D VGND VGND VPWR VPWR _8129_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_0_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_87_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_85_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5830_ _6897_/X _6061_/B _5828_/Y _5829_/X VGND VGND VPWR VPWR _5831_/A sky130_fd_sc_hd__o22a_1
XFILLER_62_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5761_ _8039_/Q _5755_/X _4647_/A _5756_/X VGND VGND VPWR VPWR _8039_/D sky130_fd_sc_hd__a22o_1
XFILLER_61_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7500_ _8966_/Q _8390_/Q _8166_/Q _8742_/Q _7500_/S0 _7599_/S1 VGND VGND VPWR VPWR
+ _7500_/X sky130_fd_sc_hd__mux4_1
X_4712_ _8673_/Q _4684_/A _4661_/X _4685_/A VGND VGND VPWR VPWR _8673_/D sky130_fd_sc_hd__a22o_1
X_8480_ _8928_/CLK _8480_/D VGND VGND VPWR VPWR _8480_/Q sky130_fd_sc_hd__dfxtp_1
X_7431_ _7427_/X _7428_/X _7429_/X _7430_/X _7711_/S0 _6097_/A VGND VGND VPWR VPWR
+ _7431_/X sky130_fd_sc_hd__mux4_1
X_5692_ _8086_/Q _5686_/X _4611_/A _5687_/X VGND VGND VPWR VPWR _8086_/D sky130_fd_sc_hd__a22o_1
X_4643_ _4643_/A VGND VGND VPWR VPWR _4643_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_116_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4574_ _8744_/Q _4569_/X _4370_/X _4570_/X VGND VGND VPWR VPWR _8744_/D sky130_fd_sc_hd__a22o_1
X_7362_ _8829_/Q _8349_/Q _8957_/Q _8477_/Q _7374_/S0 _7374_/S1 VGND VGND VPWR VPWR
+ _7362_/X sky130_fd_sc_hd__mux4_1
XFILLER_115_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7293_ _8438_/Q _8310_/Q _8374_/Q _8566_/Q _7335_/S0 _7335_/S1 VGND VGND VPWR VPWR
+ _7293_/X sky130_fd_sc_hd__mux4_1
X_6313_ _6309_/A _6262_/X _6304_/Y _6309_/X _6312_/X VGND VGND VPWR VPWR _6358_/A
+ sky130_fd_sc_hd__o221a_1
XFILLER_131_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_9032_ _9061_/CLK _9032_/D VGND VGND VPWR VPWR _9032_/Q sky130_fd_sc_hd__dfxtp_1
X_6244_ input3/X VGND VGND VPWR VPWR _6244_/Y sky130_fd_sc_hd__inv_2
XFILLER_130_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6175_ input7/X VGND VGND VPWR VPWR _6176_/A sky130_fd_sc_hd__clkbuf_2
X_5126_ _8420_/Q _5122_/X _4928_/X _5123_/X VGND VGND VPWR VPWR _8420_/D sky130_fd_sc_hd__a22o_1
X_5057_ _8467_/Q _5053_/X _4892_/X _5054_/X VGND VGND VPWR VPWR _8467_/D sky130_fd_sc_hd__a22o_1
X_4008_ _6806_/X VGND VGND VPWR VPWR _4597_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_80_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8816_ _8816_/CLK _8816_/D VGND VGND VPWR VPWR _8816_/Q sky130_fd_sc_hd__dfxtp_1
X_8747_ _9033_/CLK _8747_/D VGND VGND VPWR VPWR _8747_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_80_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5959_ _6830_/S _6621_/A _6435_/B _6606_/A VGND VGND VPWR VPWR _6086_/B sky130_fd_sc_hd__or4bb_4
XFILLER_25_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_8678_ _8710_/CLK _8678_/D VGND VGND VPWR VPWR _8678_/Q sky130_fd_sc_hd__dfxtp_1
X_7629_ _8108_/Q _8076_/Q _8044_/Q _9036_/Q _7665_/S0 _6099_/A VGND VGND VPWR VPWR
+ _7629_/X sky130_fd_sc_hd__mux4_1
XFILLER_106_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_4 _4529_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_125_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4290_ _8912_/Q _4288_/X _4049_/X _4289_/X VGND VGND VPWR VPWR _8912_/D sky130_fd_sc_hd__a22o_1
XFILLER_79_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_121_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_7980_ _8990_/Q _8414_/Q _8190_/Q _8766_/Q _8025_/S0 _8000_/S1 VGND VGND VPWR VPWR
+ _7980_/X sky130_fd_sc_hd__mux4_1
XFILLER_67_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6931_ _7024_/X _7027_/X _6963_/S VGND VGND VPWR VPWR _6931_/X sky130_fd_sc_hd__mux2_1
X_6862_ _6911_/X _6910_/X _6964_/S VGND VGND VPWR VPWR _6862_/X sky130_fd_sc_hd__mux2_1
X_5813_ _5813_/A VGND VGND VPWR VPWR _6061_/B sky130_fd_sc_hd__buf_1
XFILLER_62_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_8601_ _8794_/CLK _8601_/D VGND VGND VPWR VPWR _8601_/Q sky130_fd_sc_hd__dfxtp_1
X_6793_ _6659_/Y _6669_/Y _6809_/S VGND VGND VPWR VPWR _6793_/X sky130_fd_sc_hd__mux2_4
X_8532_ _8947_/CLK _8532_/D VGND VGND VPWR VPWR _8532_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_34_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5744_ _8052_/Q _5741_/X _4617_/A _5742_/X VGND VGND VPWR VPWR _8052_/D sky130_fd_sc_hd__a22o_1
X_5675_ _5723_/A _5675_/B VGND VGND VPWR VPWR _5714_/A sky130_fd_sc_hd__or2_4
X_8463_ _8943_/CLK _8463_/D VGND VGND VPWR VPWR _8463_/Q sky130_fd_sc_hd__dfxtp_1
X_8394_ _9033_/CLK _8394_/D VGND VGND VPWR VPWR _8394_/Q sky130_fd_sc_hd__dfxtp_1
X_7414_ _8514_/Q _8898_/Q _8834_/Q _8866_/Q _7480_/S0 _7615_/S1 VGND VGND VPWR VPWR
+ _7414_/X sky130_fd_sc_hd__mux4_2
X_4626_ _4626_/A VGND VGND VPWR VPWR _4626_/X sky130_fd_sc_hd__clkbuf_2
X_7345_ _8731_/Q _8699_/Q _8667_/Q _8635_/Q _6343_/A _6344_/B VGND VGND VPWR VPWR
+ _7345_/X sky130_fd_sc_hd__mux4_2
XFILLER_131_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4557_ _8757_/Q _4555_/X _4339_/X _4556_/X VGND VGND VPWR VPWR _8757_/D sky130_fd_sc_hd__a22o_1
XFILLER_131_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4488_ _6810_/X _4858_/B _4488_/C VGND VGND VPWR VPWR _5579_/B sky130_fd_sc_hd__or3_4
X_7276_ _7272_/X _7273_/X _7274_/X _7275_/X _7286_/S0 input36/X VGND VGND VPWR VPWR
+ _7276_/X sky130_fd_sc_hd__mux4_2
XFILLER_1_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_9015_ _9049_/CLK _9015_/D VGND VGND VPWR VPWR _9015_/Q sky130_fd_sc_hd__dfxtp_1
X_6227_ input7/X _6227_/B VGND VGND VPWR VPWR _6227_/Y sky130_fd_sc_hd__nor2_1
XFILLER_103_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_6158_ _6158_/A VGND VGND VPWR VPWR _6159_/B sky130_fd_sc_hd__inv_2
X_5109_ _5123_/A VGND VGND VPWR VPWR _5109_/X sky130_fd_sc_hd__buf_2
XFILLER_85_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6089_ _5824_/Y _5825_/X _5824_/Y _5825_/X VGND VGND VPWR VPWR _6089_/X sky130_fd_sc_hd__o2bb2a_1
XFILLER_57_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xoutput52 _9077_/Q VGND VGND VPWR VPWR imAddr[21] sky130_fd_sc_hd__clkbuf_2
XFILLER_134_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput41 _9067_/Q VGND VGND VPWR VPWR imAddr[11] sky130_fd_sc_hd__clkbuf_2
Xoutput63 _9087_/Q VGND VGND VPWR VPWR imAddr[31] sky130_fd_sc_hd__clkbuf_2
Xoutput85 _6727_/X VGND VGND VPWR VPWR regData[22] sky130_fd_sc_hd__clkbuf_2
Xoutput74 _6707_/X VGND VGND VPWR VPWR regData[12] sky130_fd_sc_hd__clkbuf_2
Xoutput96 _6689_/X VGND VGND VPWR VPWR regData[3] sky130_fd_sc_hd__clkbuf_2
XFILLER_0_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5460_ _6787_/X VGND VGND VPWR VPWR _5460_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_118_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4411_ _8853_/Q _4409_/X _4339_/X _4410_/X VGND VGND VPWR VPWR _8853_/D sky130_fd_sc_hd__a22o_1
XFILLER_126_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5391_ _8265_/Q _5387_/X _5188_/X _5388_/X VGND VGND VPWR VPWR _8265_/D sky130_fd_sc_hd__a22o_1
XFILLER_113_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7130_ _8965_/Q _8389_/Q _8165_/Q _8741_/Q _7130_/S0 _7135_/S1 VGND VGND VPWR VPWR
+ _7130_/X sky130_fd_sc_hd__mux4_1
X_4342_ _4617_/A VGND VGND VPWR VPWR _4342_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_98_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4273_ _8923_/Q _4265_/X _4012_/X _4268_/X VGND VGND VPWR VPWR _8923_/D sky130_fd_sc_hd__a22o_1
X_7061_ _7966_/X _7971_/X _7067_/S VGND VGND VPWR VPWR _7061_/X sky130_fd_sc_hd__mux2_1
XFILLER_101_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6012_ _7024_/X VGND VGND VPWR VPWR _6454_/A sky130_fd_sc_hd__inv_2
.ends
